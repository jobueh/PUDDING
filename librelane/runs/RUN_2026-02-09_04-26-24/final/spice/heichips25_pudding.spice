* NGSPICE file created from heichips25_pudding.ext - technology: ihp-sg13g2

* Black-box entry subcircuit for sg13g2_decap_8 abstract view
.subckt sg13g2_decap_8 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_nand2_1 abstract view
.subckt sg13g2_nand2_1 Y A B VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_tiehi abstract view
.subckt sg13g2_tiehi VDD VSS L_HI
.ends

* Black-box entry subcircuit for sg13g2_a221oi_1 abstract view
.subckt sg13g2_a221oi_1 VDD VSS B2 C1 B1 A1 Y A2
.ends

* Black-box entry subcircuit for sg13g2_fill_1 abstract view
.subckt sg13g2_fill_1 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_fill_2 abstract view
.subckt sg13g2_fill_2 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_decap_4 abstract view
.subckt sg13g2_decap_4 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_o21ai_1 abstract view
.subckt sg13g2_o21ai_1 B1 VDD Y VSS A1 A2
.ends

* Black-box entry subcircuit for sg13g2_buf_1 abstract view
.subckt sg13g2_buf_1 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_1 abstract view
.subckt sg13g2_inv_1 VDD Y A VSS
.ends

* Black-box entry subcircuit for sg13g2_dfrbpq_1 abstract view
.subckt sg13g2_dfrbpq_1 RESET_B VSS VDD D Q CLK
.ends

* Black-box entry subcircuit for sg13g2_a21oi_1 abstract view
.subckt sg13g2_a21oi_1 VSS VDD A1 A2 Y B1
.ends

* Black-box entry subcircuit for sg13g2_a21o_1 abstract view
.subckt sg13g2_a21o_1 A2 A1 B1 X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_antennanp abstract view
.subckt sg13g2_antennanp VDD VSS A
.ends

* Black-box entry subcircuit for sg13g2_buf_8 abstract view
.subckt sg13g2_buf_8 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_2 abstract view
.subckt sg13g2_inv_2 Y A VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_4 abstract view
.subckt sg13g2_inv_4 A Y VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_16 abstract view
.subckt sg13g2_buf_16 X A VDD VSS
.ends

* Black-box entry subcircuit for dac128module abstract view
.subckt dac128module ON[64] ONB[64] ON[65] ONB[65] ON[66] ONB[66] ON[67] ONB[67] ON[68]
+ ONB[68] ON[69] ONB[69] ON[70] ONB[70] ON[71] ONB[71] ON[72] ONB[72] EN[2] ENB[2]
+ ON[73] ONB[73] ON[74] ONB[74] ON[75] ONB[75] ON[76] ONB[76] ON[77] ONB[77] ON[78]
+ ONB[78] ON[79] ONB[79] ON[80] ONB[80] ON[81] ONB[81] ON[82] ONB[82] ON[83] ONB[83]
+ ON[84] ONB[84] ON[85] ONB[85] ON[86] ONB[86] ON[87] ONB[87] ON[88] ONB[88] ON[89]
+ ONB[89] ON[90] ONB[90] ON[91] ONB[91] ON[92] ONB[92] ON[93] ONB[93] ON[94] ONB[94]
+ ON[95] ONB[95] ON[96] ONB[96] ON[97] ONB[97] ON[98] ONB[98] ON[99] ONB[99] ON[100]
+ ONB[100] ON[101] ONB[101] ON[102] ONB[102] ON[103] ONB[103] ON[104] ONB[104] ON[105]
+ ONB[105] ON[106] ONB[106] ON[107] ONB[107] ON[108] ONB[108] ON[109] ONB[109] ON[110]
+ ONB[110] ON[111] ONB[111] ON[112] ONB[112] ON[113] ONB[113] ON[114] ONB[114] ON[115]
+ ONB[115] ON[116] ONB[116] ON[117] ONB[117] ON[118] ONB[118] ON[119] ONB[119] ON[120]
+ ONB[120] ON[121] ONB[121] ON[122] ONB[122] EN[3] ENB[3] ON[123] ONB[123] ON[124]
+ ONB[124] ON[125] ONB[125] ON[126] ONB[126] ON[127] ONB[127] ON[0] ONB[0] ON[1] ONB[1]
+ ON[2] ONB[2] ON[3] ONB[3] ON[4] ONB[4] ON[5] ONB[5] ON[6] EN[0] ENB[0] ONB[6] ON[7]
+ ONB[7] ON[8] ONB[8] ON[9] ONB[9] ON[10] ONB[10] ON[11] ONB[11] ON[12] ONB[12] ON[13]
+ ONB[13] ON[14] ONB[14] ON[15] ONB[15] ON[16] ONB[16] ON[17] ONB[17] ON[18] ONB[18]
+ ON[19] ONB[19] ON[20] ONB[20] ON[21] ONB[21] ON[22] ONB[22] ON[23] ONB[23] ON[24]
+ ONB[24] ON[25] ONB[25] ON[26] ONB[26] ON[27] ONB[27] ON[28] ONB[28] ON[29] ONB[29]
+ ON[30] ONB[30] ON[31] ONB[31] ON[33] ONB[33] ON[32] ONB[32] ON[34] ONB[34] ON[35]
+ ONB[35] ON[36] ONB[36] ON[37] ONB[37] ON[38] ONB[38] ON[39] ONB[39] ON[40] ONB[40]
+ ON[41] ONB[41] ON[42] ONB[42] ON[43] ONB[43] ON[44] ONB[44] ON[45] ONB[45] ON[46]
+ ONB[46] ON[47] ONB[47] ON[48] ONB[48] ON[49] ONB[49] ON[50] ONB[50] ON[51] ONB[51]
+ ON[52] ONB[52] ON[53] ONB[53] ON[54] ONB[54] ON[55] ONB[55] ON[56] ONB[56] ON[57]
+ ONB[57] ON[58] ONB[58] ON[59] ONB[59] ON[60] ONB[60] ON[61] ONB[61] ON[62] ONB[62]
+ ON[63] ONB[63] EN[1] ENB[1] VSS VDD
.ends

* Black-box entry subcircuit for sg13g2_nor2_1 abstract view
.subckt sg13g2_nor2_1 A B Y VDD VSS
.ends

.subckt heichips25_pudding VGND VPWR clk ena rst_n ui_in[0] ui_in[1] ui_in[2] ui_in[3]
+ ui_in[4] ui_in[5] ui_in[6] ui_in[7] uio_in[0] uio_in[1] uio_in[2] uio_in[3] uio_in[4]
+ uio_in[5] uio_in[6] uio_in[7] uio_oe[0] uio_oe[1] uio_oe[2] uio_oe[3] uio_oe[4]
+ uio_oe[5] uio_oe[6] uio_oe[7] uio_out[0] uio_out[1] uio_out[2] uio_out[3] uio_out[4]
+ uio_out[5] uio_out[6] uio_out[7] uo_out[0] uo_out[1] uo_out[2] uo_out[3] uo_out[4]
+ uo_out[5] uo_out[6] uo_out[7]
XFILLER_39_266 VPWR VGND sg13g2_decap_8
X_2106_ _0924_ net124 state\[26\] VPWR VGND sg13g2_nand2_1
X_2493__270 VPWR VGND net269 sg13g2_tiehi
X_2037_ VPWR VGND _0885_ net71 _0884_ _0154_ _0379_ net25 sg13g2_a221oi_1
XFILLER_35_472 VPWR VGND sg13g2_decap_8
XFILLER_22_144 VPWR VGND sg13g2_decap_8
XFILLER_7_7 VPWR VGND sg13g2_decap_8
XFILLER_2_516 VPWR VGND sg13g2_decap_8
XFILLER_45_203 VPWR VGND sg13g2_decap_8
X_2472__354 VPWR VGND net353 sg13g2_tiehi
XFILLER_26_74 VPWR VGND sg13g2_decap_8
XFILLER_14_612 VPWR VGND sg13g2_decap_8
XFILLER_26_494 VPWR VGND sg13g2_fill_1
XFILLER_14_645 VPWR VGND sg13g2_decap_8
XFILLER_13_144 VPWR VGND sg13g2_decap_8
XFILLER_9_137 VPWR VGND sg13g2_decap_8
XFILLER_42_84 VPWR VGND sg13g2_decap_8
XFILLER_5_354 VPWR VGND sg13g2_decap_8
XFILLER_1_560 VPWR VGND sg13g2_decap_8
XFILLER_49_520 VPWR VGND sg13g2_fill_2
XFILLER_3_67 VPWR VGND sg13g2_decap_8
XFILLER_37_715 VPWR VGND sg13g2_decap_4
XFILLER_49_597 VPWR VGND sg13g2_fill_1
XFILLER_36_203 VPWR VGND sg13g2_decap_8
X_2451__438 VPWR VGND net437 sg13g2_tiehi
XFILLER_44_280 VPWR VGND sg13g2_decap_8
XFILLER_32_420 VPWR VGND sg13g2_fill_2
XFILLER_20_604 VPWR VGND sg13g2_fill_1
X_1606_ net211 VPWR _0562_ VGND state\[16\] net171 sg13g2_o21ai_1
Xfanout138 net141 net138 VPWR VGND sg13g2_buf_1
Xfanout127 net128 net127 VPWR VGND sg13g2_buf_1
Xfanout116 net119 net116 VPWR VGND sg13g2_buf_1
Xfanout105 net106 net105 VPWR VGND sg13g2_buf_1
X_1537_ VPWR _0178_ daisychain\[2\] VGND sg13g2_inv_1
Xfanout149 net150 net149 VPWR VGND sg13g2_buf_1
X_1468_ VPWR _0224_ daisychain\[71\] VGND sg13g2_inv_1
X_1399_ VPWR _0031_ state\[12\] VGND sg13g2_inv_1
XFILLER_27_203 VPWR VGND sg13g2_decap_8
XFILLER_42_217 VPWR VGND sg13g2_decap_8
XFILLER_35_280 VPWR VGND sg13g2_decap_8
XFILLER_23_420 VPWR VGND sg13g2_decap_8
XFILLER_10_158 VPWR VGND sg13g2_decap_8
XFILLER_12_32 VPWR VGND sg13g2_decap_8
XFILLER_5_4 VPWR VGND sg13g2_decap_8
XFILLER_2_368 VPWR VGND sg13g2_decap_8
XFILLER_46_523 VPWR VGND sg13g2_fill_2
XFILLER_46_512 VPWR VGND sg13g2_decap_8
XFILLER_18_214 VPWR VGND sg13g2_decap_8
XFILLER_37_84 VPWR VGND sg13g2_decap_8
XFILLER_27_781 VPWR VGND sg13g2_fill_2
XFILLER_33_228 VPWR VGND sg13g2_decap_8
XFILLER_26_291 VPWR VGND sg13g2_decap_8
XFILLER_14_431 VPWR VGND sg13g2_decap_8
XFILLER_14_442 VPWR VGND sg13g2_fill_1
XFILLER_41_294 VPWR VGND sg13g2_decap_8
X_2440_ net481 VGND VPWR _0386_ state\[2\] clknet_leaf_2_clk sg13g2_dfrbpq_1
XFILLER_5_151 VPWR VGND sg13g2_decap_8
X_2371_ net366 VGND VPWR _0317_ daisychain\[61\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1322_ VPWR _0115_ state\[89\] VGND sg13g2_inv_1
XFILLER_49_361 VPWR VGND sg13g2_decap_8
XFILLER_24_228 VPWR VGND sg13g2_decap_8
XFILLER_17_280 VPWR VGND sg13g2_decap_8
XFILLER_21_935 VPWR VGND sg13g2_fill_1
XFILLER_0_828 VPWR VGND sg13g2_decap_8
XFILLER_15_228 VPWR VGND sg13g2_decap_8
XFILLER_11_445 VPWR VGND sg13g2_decap_8
XFILLER_23_53 VPWR VGND sg13g2_decap_8
XFILLER_7_416 VPWR VGND sg13g2_decap_8
XFILLER_2_165 VPWR VGND sg13g2_decap_8
XFILLER_0_35 VPWR VGND sg13g2_decap_8
XFILLER_46_364 VPWR VGND sg13g2_decap_8
XFILLER_34_515 VPWR VGND sg13g2_fill_1
XFILLER_9_11 VPWR VGND sg13g2_decap_8
X_1940_ VGND VPWR net142 daisychain\[98\] _0813_ net47 sg13g2_a21oi_1
X_1871_ net201 _0236_ _0760_ _0761_ VPWR VGND sg13g2_a21o_1
XFILLER_9_88 VPWR VGND sg13g2_decap_8
XFILLER_6_482 VPWR VGND sg13g2_decap_8
X_2423_ net262 VGND VPWR _0369_ daisychain\[113\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2354_ net400 VGND VPWR _0300_ daisychain\[44\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1305_ VPWR _0007_ state\[106\] VGND sg13g2_inv_1
X_2285_ VGND VPWR _0860_ _1013_ _0499_ net83 sg13g2_a21oi_1
XFILLER_37_364 VPWR VGND sg13g2_fill_2
XFILLER_37_397 VPWR VGND sg13g2_fill_1
XFILLER_37_386 VPWR VGND sg13g2_decap_8
XFILLER_25_548 VPWR VGND sg13g2_fill_2
XFILLER_33_592 VPWR VGND sg13g2_fill_2
XFILLER_20_242 VPWR VGND sg13g2_decap_8
XFILLER_21_798 VPWR VGND sg13g2_fill_2
XFILLER_21_776 VPWR VGND sg13g2_fill_1
XFILLER_0_658 VPWR VGND sg13g2_decap_4
XFILLER_18_53 VPWR VGND sg13g2_decap_8
XFILLER_44_813 VPWR VGND sg13g2_fill_2
XFILLER_43_301 VPWR VGND sg13g2_decap_8
X_2434__241 VPWR VGND net240 sg13g2_tiehi
XFILLER_12_710 VPWR VGND sg13g2_decap_8
XFILLER_12_721 VPWR VGND sg13g2_fill_2
XFILLER_43_378 VPWR VGND sg13g2_fill_1
XFILLER_34_74 VPWR VGND sg13g2_decap_8
XFILLER_11_242 VPWR VGND sg13g2_decap_8
XFILLER_7_224 VPWR VGND sg13g2_decap_8
XFILLER_4_920 VPWR VGND sg13g2_decap_8
X_2365__379 VPWR VGND net378 sg13g2_tiehi
XFILLER_4_931 VPWR VGND sg13g2_fill_2
XFILLER_3_452 VPWR VGND sg13g2_decap_8
XFILLER_39_629 VPWR VGND sg13g2_fill_2
X_2070_ _0906_ net118 state\[8\] VPWR VGND sg13g2_nand2_1
XFILLER_19_375 VPWR VGND sg13g2_decap_8
XFILLER_46_161 VPWR VGND sg13g2_decap_8
XFILLER_34_312 VPWR VGND sg13g2_decap_8
XFILLER_15_581 VPWR VGND sg13g2_decap_8
XFILLER_15_570 VPWR VGND sg13g2_decap_8
X_1923_ net187 _0250_ _0799_ _0800_ VPWR VGND sg13g2_a21o_1
X_1854_ net229 VPWR _0748_ VGND state\[78\] net204 sg13g2_o21ai_1
X_1785_ VPWR VGND _0696_ net106 _0695_ _0212_ _0316_ net57 sg13g2_a221oi_1
X_2406_ net296 VGND VPWR _0352_ daisychain\[96\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_2337_ net434 VGND VPWR _0283_ daisychain\[27\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2268_ _1005_ net134 state\[107\] VPWR VGND sg13g2_nand2_1
X_2199_ VGND VPWR _0731_ _0970_ _0456_ net111 sg13g2_a21oi_1
XFILLER_37_161 VPWR VGND sg13g2_decap_8
XFILLER_26_857 VPWR VGND sg13g2_fill_2
XFILLER_25_312 VPWR VGND sg13g2_decap_8
XFILLER_40_315 VPWR VGND sg13g2_decap_8
XFILLER_21_551 VPWR VGND sg13g2_fill_2
X_2468__370 VPWR VGND net369 sg13g2_tiehi
XFILLER_4_249 VPWR VGND sg13g2_decap_8
XFILLER_20_32 VPWR VGND sg13g2_decap_8
XFILLER_0_455 VPWR VGND sg13g2_decap_8
XFILLER_48_415 VPWR VGND sg13g2_decap_8
XFILLER_29_74 VPWR VGND sg13g2_decap_8
XFILLER_28_172 VPWR VGND sg13g2_decap_8
XFILLER_16_312 VPWR VGND sg13g2_decap_8
XFILLER_44_665 VPWR VGND sg13g2_decap_8
XFILLER_45_84 VPWR VGND sg13g2_decap_8
XFILLER_43_175 VPWR VGND sg13g2_decap_8
XFILLER_31_326 VPWR VGND sg13g2_decap_8
XFILLER_16_389 VPWR VGND sg13g2_decap_8
XFILLER_8_522 VPWR VGND sg13g2_decap_8
XFILLER_12_595 VPWR VGND sg13g2_decap_4
X_2447__454 VPWR VGND net453 sg13g2_tiehi
XANTENNA_5 VPWR VGND _0164_ sg13g2_antennanp
X_1570_ net212 VPWR _0535_ VGND state\[7\] net164 sg13g2_o21ai_1
XFILLER_6_67 VPWR VGND sg13g2_decap_8
XFILLER_4_761 VPWR VGND sg13g2_fill_1
XFILLER_39_404 VPWR VGND sg13g2_decap_8
XFILLER_20_4 VPWR VGND sg13g2_decap_8
X_2122_ _0932_ net123 state\[34\] VPWR VGND sg13g2_nand2_1
XFILLER_26_109 VPWR VGND sg13g2_decap_8
X_2053_ VPWR VGND _0897_ net72 _0896_ _0158_ _0383_ net26 sg13g2_a221oi_1
XFILLER_47_481 VPWR VGND sg13g2_decap_8
XFILLER_35_621 VPWR VGND sg13g2_fill_1
XFILLER_19_172 VPWR VGND sg13g2_decap_8
XFILLER_34_186 VPWR VGND sg13g2_decap_8
XFILLER_22_326 VPWR VGND sg13g2_decap_8
X_1906_ net230 VPWR _0787_ VGND state\[91\] net203 sg13g2_o21ai_1
X_1837_ VPWR VGND _0735_ net107 _0734_ _0226_ _0329_ net59 sg13g2_a221oi_1
X_1768_ VGND VPWR net152 daisychain\[55\] _0684_ net56 sg13g2_a21oi_1
X_1699_ net170 _0188_ _0631_ _0632_ VPWR VGND sg13g2_a21o_1
XFILLER_26_610 VPWR VGND sg13g2_decap_8
XFILLER_15_32 VPWR VGND sg13g2_decap_8
XFILLER_13_326 VPWR VGND sg13g2_decap_8
XFILLER_40_112 VPWR VGND sg13g2_decap_8
XFILLER_25_186 VPWR VGND sg13g2_decap_8
XFILLER_9_319 VPWR VGND sg13g2_decap_8
XFILLER_40_189 VPWR VGND sg13g2_decap_8
XFILLER_5_503 VPWR VGND sg13g2_decap_8
XFILLER_31_53 VPWR VGND sg13g2_decap_8
Xoutput20 net20 uo_out[4] VPWR VGND sg13g2_buf_1
XFILLER_0_252 VPWR VGND sg13g2_decap_8
XFILLER_49_746 VPWR VGND sg13g2_decap_8
XFILLER_1_797 VPWR VGND sg13g2_fill_1
XdigitalenH.g\[1\].u.inv1 VPWR digitalenH.g\[1\].u.OUTN net7 VGND sg13g2_inv_1
XFILLER_49_779 VPWR VGND sg13g2_decap_8
XFILLER_48_245 VPWR VGND sg13g2_decap_8
XFILLER_29_492 VPWR VGND sg13g2_decap_8
XFILLER_44_495 VPWR VGND sg13g2_fill_2
XFILLER_32_635 VPWR VGND sg13g2_fill_1
XFILLER_31_123 VPWR VGND sg13g2_decap_8
XFILLER_16_186 VPWR VGND sg13g2_decap_8
X_1622_ net218 VPWR _0574_ VGND state\[20\] net183 sg13g2_o21ai_1
XFILLER_8_396 VPWR VGND sg13g2_decap_8
X_1553_ VPWR VGND _0522_ net84 _0521_ _0178_ _0258_ net38 sg13g2_a221oi_1
X_1484_ VPWR _0206_ daisychain\[55\] VGND sg13g2_inv_1
XFILLER_4_580 VPWR VGND sg13g2_decap_4
XFILLER_39_245 VPWR VGND sg13g2_decap_8
X_2105_ VGND VPWR _0590_ _0923_ _0409_ net78 sg13g2_a21oi_1
X_2036_ VGND VPWR net116 daisychain\[122\] _0885_ net26 sg13g2_a21oi_1
XFILLER_23_646 VPWR VGND sg13g2_decap_4
XFILLER_22_123 VPWR VGND sg13g2_decap_8
XFILLER_31_690 VPWR VGND sg13g2_decap_4
X_2502__234 VPWR VGND net sg13g2_tiehi
XFILLER_45_259 VPWR VGND sg13g2_decap_8
XFILLER_27_996 VPWR VGND sg13g2_decap_4
XFILLER_27_985 VPWR VGND sg13g2_fill_2
XFILLER_26_53 VPWR VGND sg13g2_decap_8
XFILLER_13_123 VPWR VGND sg13g2_decap_8
XFILLER_9_116 VPWR VGND sg13g2_decap_8
XFILLER_41_465 VPWR VGND sg13g2_fill_1
XFILLER_42_63 VPWR VGND sg13g2_decap_8
XFILLER_5_333 VPWR VGND sg13g2_decap_8
XFILLER_3_46 VPWR VGND sg13g2_decap_8
XFILLER_49_576 VPWR VGND sg13g2_decap_8
XFILLER_49_554 VPWR VGND sg13g2_decap_8
XFILLER_36_259 VPWR VGND sg13g2_decap_8
XFILLER_45_771 VPWR VGND sg13g2_fill_1
XFILLER_8_193 VPWR VGND sg13g2_decap_8
X_1605_ VPWR VGND _0561_ net75 _0560_ _0162_ _0271_ net29 sg13g2_a221oi_1
X_1536_ VPWR _0189_ daisychain\[3\] VGND sg13g2_inv_1
Xfanout128 net146 net128 VPWR VGND sg13g2_buf_1
Xfanout117 net119 net117 VPWR VGND sg13g2_buf_1
Xfanout106 net115 net106 VPWR VGND sg13g2_buf_1
Xfanout139 net141 net139 VPWR VGND sg13g2_buf_1
X_1467_ VPWR _0225_ daisychain\[72\] VGND sg13g2_inv_1
X_1398_ VPWR _0032_ state\[13\] VGND sg13g2_inv_1
XFILLER_28_727 VPWR VGND sg13g2_fill_1
XFILLER_27_259 VPWR VGND sg13g2_decap_8
X_2019_ net181 _0149_ _0871_ _0872_ VPWR VGND sg13g2_a21o_1
XFILLER_24_955 VPWR VGND sg13g2_decap_8
XFILLER_10_137 VPWR VGND sg13g2_decap_8
XFILLER_12_11 VPWR VGND sg13g2_decap_8
XFILLER_12_88 VPWR VGND sg13g2_decap_8
XFILLER_2_347 VPWR VGND sg13g2_decap_8
XFILLER_37_63 VPWR VGND sg13g2_decap_8
XFILLER_33_207 VPWR VGND sg13g2_decap_8
XFILLER_26_270 VPWR VGND sg13g2_decap_8
XFILLER_14_410 VPWR VGND sg13g2_decap_8
XFILLER_41_273 VPWR VGND sg13g2_decap_8
XFILLER_5_130 VPWR VGND sg13g2_decap_8
XFILLER_6_686 VPWR VGND sg13g2_fill_2
X_2370_ net368 VGND VPWR _0316_ daisychain\[60\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1321_ VPWR _0117_ state\[90\] VGND sg13g2_inv_1
XFILLER_49_340 VPWR VGND sg13g2_decap_8
XFILLER_37_524 VPWR VGND sg13g2_decap_4
X_2375__359 VPWR VGND net358 sg13g2_tiehi
XFILLER_37_535 VPWR VGND sg13g2_decap_8
XFILLER_24_207 VPWR VGND sg13g2_decap_8
X_2531__260 VPWR VGND net259 sg13g2_tiehi
XFILLER_21_914 VPWR VGND sg13g2_fill_1
XFILLER_32_284 VPWR VGND sg13g2_decap_8
XFILLER_21_947 VPWR VGND sg13g2_fill_1
XFILLER_9_480 VPWR VGND sg13g2_decap_8
XFILLER_0_807 VPWR VGND sg13g2_fill_2
X_2499_ net245 VGND VPWR _0445_ state\[61\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1519_ VPWR _0168_ daisychain\[20\] VGND sg13g2_inv_1
XFILLER_15_207 VPWR VGND sg13g2_decap_8
XFILLER_11_424 VPWR VGND sg13g2_decap_8
XFILLER_23_32 VPWR VGND sg13g2_decap_8
XFILLER_23_284 VPWR VGND sg13g2_decap_8
XFILLER_2_144 VPWR VGND sg13g2_decap_8
XFILLER_48_84 VPWR VGND sg13g2_decap_8
XFILLER_0_14 VPWR VGND sg13g2_decap_8
XFILLER_46_343 VPWR VGND sg13g2_decap_8
XFILLER_19_535 VPWR VGND sg13g2_fill_2
XFILLER_27_590 VPWR VGND sg13g2_decap_8
XFILLER_42_560 VPWR VGND sg13g2_decap_8
XFILLER_30_722 VPWR VGND sg13g2_fill_1
X_1870_ net229 VPWR _0760_ VGND state\[82\] net201 sg13g2_o21ai_1
XFILLER_9_67 VPWR VGND sg13g2_decap_8
XFILLER_14_284 VPWR VGND sg13g2_decap_8
XFILLER_6_461 VPWR VGND sg13g2_decap_8
X_2422_ net264 VGND VPWR _0368_ daisychain\[112\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2353_ net402 VGND VPWR _0299_ daisychain\[43\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1304_ VPWR _0008_ state\[107\] VGND sg13g2_inv_1
X_2284_ _1013_ net130 state\[115\] VPWR VGND sg13g2_nand2_1
XFILLER_37_343 VPWR VGND sg13g2_decap_8
XFILLER_21_700 VPWR VGND sg13g2_decap_4
XFILLER_21_733 VPWR VGND sg13g2_decap_8
XFILLER_20_221 VPWR VGND sg13g2_decap_8
X_1999_ net175 _0144_ _0856_ _0857_ VPWR VGND sg13g2_a21o_1
XFILLER_20_298 VPWR VGND sg13g2_decap_8
X_2505__468 VPWR VGND net467 sg13g2_tiehi
XFILLER_0_637 VPWR VGND sg13g2_decap_8
X_2440__482 VPWR VGND net481 sg13g2_tiehi
XFILLER_18_32 VPWR VGND sg13g2_decap_8
XFILLER_28_354 VPWR VGND sg13g2_decap_8
XFILLER_16_549 VPWR VGND sg13g2_fill_2
XFILLER_43_357 VPWR VGND sg13g2_decap_8
XFILLER_34_53 VPWR VGND sg13g2_decap_8
XFILLER_31_519 VPWR VGND sg13g2_fill_2
XFILLER_11_221 VPWR VGND sg13g2_decap_8
XFILLER_7_203 VPWR VGND sg13g2_decap_8
XFILLER_11_298 VPWR VGND sg13g2_decap_8
XFILLER_3_431 VPWR VGND sg13g2_decap_8
XFILLER_47_663 VPWR VGND sg13g2_fill_1
XFILLER_46_140 VPWR VGND sg13g2_decap_8
XFILLER_19_354 VPWR VGND sg13g2_decap_8
XFILLER_34_368 VPWR VGND sg13g2_decap_8
XFILLER_15_560 VPWR VGND sg13g2_fill_1
X_1922_ net220 VPWR _0799_ VGND state\[95\] net187 sg13g2_o21ai_1
X_1853_ VPWR VGND _0747_ net112 _0746_ _0230_ _0333_ net66 sg13g2_a221oi_1
X_1784_ VGND VPWR net152 daisychain\[59\] _0696_ net57 sg13g2_a21oi_1
XFILLER_6_291 VPWR VGND sg13g2_decap_8
X_2405_ net298 VGND VPWR _0351_ daisychain\[95\] clknet_leaf_6_clk sg13g2_dfrbpq_1
XFILLER_41_0 VPWR VGND sg13g2_decap_8
X_2336_ net436 VGND VPWR _0282_ daisychain\[26\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2267_ VGND VPWR _0833_ _1004_ _0490_ net85 sg13g2_a21oi_1
XFILLER_37_140 VPWR VGND sg13g2_decap_8
X_2198_ _0970_ net158 state\[72\] VPWR VGND sg13g2_nand2_1
XFILLER_25_368 VPWR VGND sg13g2_decap_4
XFILLER_4_228 VPWR VGND sg13g2_decap_8
XFILLER_20_11 VPWR VGND sg13g2_decap_8
XFILLER_20_88 VPWR VGND sg13g2_decap_8
XFILLER_0_434 VPWR VGND sg13g2_decap_8
XFILLER_1_946 VPWR VGND sg13g2_fill_2
XFILLER_29_53 VPWR VGND sg13g2_decap_8
X_2475__342 VPWR VGND net341 sg13g2_tiehi
XFILLER_29_630 VPWR VGND sg13g2_decap_4
XFILLER_21_1012 VPWR VGND sg13g2_fill_1
XFILLER_29_696 VPWR VGND sg13g2_fill_2
XFILLER_28_151 VPWR VGND sg13g2_decap_8
XFILLER_45_63 VPWR VGND sg13g2_decap_8
XFILLER_43_154 VPWR VGND sg13g2_decap_8
XFILLER_31_305 VPWR VGND sg13g2_decap_8
XFILLER_16_368 VPWR VGND sg13g2_decap_8
XFILLER_8_501 VPWR VGND sg13g2_decap_8
XANTENNA_6 VPWR VGND _0164_ sg13g2_antennanp
XFILLER_6_46 VPWR VGND sg13g2_decap_8
X_2121_ VGND VPWR _0614_ _0931_ _0417_ net78 sg13g2_a21oi_1
XFILLER_13_4 VPWR VGND sg13g2_decap_8
X_2052_ VGND VPWR net116 daisychain\[126\] _0897_ net26 sg13g2_a21oi_1
X_2454__426 VPWR VGND net425 sg13g2_tiehi
XFILLER_47_471 VPWR VGND sg13g2_fill_1
XFILLER_19_151 VPWR VGND sg13g2_decap_8
XFILLER_35_666 VPWR VGND sg13g2_fill_2
XFILLER_35_644 VPWR VGND sg13g2_decap_8
XFILLER_34_165 VPWR VGND sg13g2_decap_8
XFILLER_22_305 VPWR VGND sg13g2_decap_8
X_1905_ VPWR VGND _0786_ net108 _0785_ _0245_ _0346_ net60 sg13g2_a221oi_1
X_1836_ VGND VPWR net158 daisychain\[72\] _0735_ net59 sg13g2_a21oi_1
X_1767_ net199 _0207_ _0682_ _0683_ VPWR VGND sg13g2_a21o_1
X_1698_ net224 VPWR _0631_ VGND state\[39\] net170 sg13g2_o21ai_1
X_2319_ net470 VGND VPWR _0265_ daisychain\[9\] clknet_leaf_0_clk sg13g2_dfrbpq_1
XFILLER_13_305 VPWR VGND sg13g2_decap_8
XFILLER_41_614 VPWR VGND sg13g2_decap_8
XFILLER_26_677 VPWR VGND sg13g2_decap_4
XFILLER_25_165 VPWR VGND sg13g2_decap_8
XFILLER_15_11 VPWR VGND sg13g2_decap_8
XFILLER_40_168 VPWR VGND sg13g2_decap_8
XFILLER_15_88 VPWR VGND sg13g2_decap_8
XFILLER_22_894 VPWR VGND sg13g2_decap_8
XFILLER_21_382 VPWR VGND sg13g2_decap_4
XFILLER_31_32 VPWR VGND sg13g2_decap_8
XFILLER_21_393 VPWR VGND sg13g2_fill_1
XFILLER_5_559 VPWR VGND sg13g2_decap_8
X_2403__303 VPWR VGND net302 sg13g2_tiehi
Xoutput10 net10 uio_out[2] VPWR VGND sg13g2_buf_1
Xoutput21 net21 uo_out[5] VPWR VGND sg13g2_buf_1
Xoutput8 net8 uio_out[0] VPWR VGND sg13g2_buf_1
XFILLER_0_231 VPWR VGND sg13g2_decap_8
XFILLER_48_224 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[1\].u.inv2 VPWR digitalenH.g\[1\].u.OUTP digitalenH.g\[1\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_17_600 VPWR VGND sg13g2_decap_8
XFILLER_17_677 VPWR VGND sg13g2_decap_8
XFILLER_16_165 VPWR VGND sg13g2_decap_8
XFILLER_31_102 VPWR VGND sg13g2_decap_8
XFILLER_12_382 VPWR VGND sg13g2_decap_8
XFILLER_31_179 VPWR VGND sg13g2_decap_8
X_1621_ VPWR VGND _0573_ net76 _0572_ _0166_ _0275_ net30 sg13g2_a221oi_1
XFILLER_8_375 VPWR VGND sg13g2_decap_8
X_1552_ VGND VPWR net131 daisychain\[1\] _0522_ net38 sg13g2_a21oi_1
X_1483_ VPWR _0207_ daisychain\[56\] VGND sg13g2_inv_1
XFILLER_39_224 VPWR VGND sg13g2_decap_8
X_2104_ _0923_ net126 state\[25\] VPWR VGND sg13g2_nand2_1
X_2035_ net165 _0154_ _0883_ _0884_ VPWR VGND sg13g2_a21o_1
XFILLER_22_102 VPWR VGND sg13g2_decap_8
XFILLER_23_658 VPWR VGND sg13g2_fill_1
XFILLER_10_319 VPWR VGND sg13g2_decap_8
XFILLER_22_179 VPWR VGND sg13g2_decap_8
X_2385__339 VPWR VGND net338 sg13g2_tiehi
X_1819_ net205 _0221_ _0721_ _0722_ VPWR VGND sg13g2_a21o_1
XFILLER_45_238 VPWR VGND sg13g2_decap_8
XFILLER_26_32 VPWR VGND sg13g2_decap_8
XFILLER_26_441 VPWR VGND sg13g2_fill_1
XFILLER_13_102 VPWR VGND sg13g2_decap_8
XFILLER_26_485 VPWR VGND sg13g2_decap_8
XFILLER_13_179 VPWR VGND sg13g2_decap_8
XFILLER_42_42 VPWR VGND sg13g2_decap_8
XFILLER_41_499 VPWR VGND sg13g2_decap_8
XFILLER_41_477 VPWR VGND sg13g2_decap_8
XFILLER_22_680 VPWR VGND sg13g2_fill_2
XFILLER_5_312 VPWR VGND sg13g2_decap_8
XFILLER_5_389 VPWR VGND sg13g2_decap_8
XFILLER_3_25 VPWR VGND sg13g2_decap_8
XFILLER_1_595 VPWR VGND sg13g2_decap_8
X_2557__280 VPWR VGND net279 sg13g2_tiehi
XFILLER_36_238 VPWR VGND sg13g2_decap_8
XFILLER_32_499 VPWR VGND sg13g2_fill_2
XFILLER_9_684 VPWR VGND sg13g2_decap_4
XFILLER_8_172 VPWR VGND sg13g2_decap_8
X_1604_ VGND VPWR net122 daisychain\[14\] _0561_ net29 sg13g2_a21oi_1
X_1535_ VPWR _0200_ daisychain\[4\] VGND sg13g2_inv_1
Xfanout129 net133 net129 VPWR VGND sg13g2_buf_1
Xfanout118 net119 net118 VPWR VGND sg13g2_buf_1
Xfanout107 net110 net107 VPWR VGND sg13g2_buf_1
X_1466_ VPWR _0226_ daisychain\[73\] VGND sg13g2_inv_1
X_1397_ VPWR _0033_ state\[14\] VGND sg13g2_inv_1
XFILLER_27_238 VPWR VGND sg13g2_decap_8
X_2018_ net215 VPWR _0871_ VGND state\[119\] net175 sg13g2_o21ai_1
XFILLER_24_989 VPWR VGND sg13g2_decap_8
XFILLER_24_978 VPWR VGND sg13g2_decap_4
XFILLER_10_116 VPWR VGND sg13g2_decap_8
XFILLER_6_109 VPWR VGND sg13g2_decap_8
XFILLER_12_67 VPWR VGND sg13g2_decap_8
X_2508__444 VPWR VGND net443 sg13g2_tiehi
XFILLER_2_326 VPWR VGND sg13g2_decap_8
XFILLER_37_42 VPWR VGND sg13g2_decap_8
XFILLER_18_249 VPWR VGND sg13g2_decap_8
XFILLER_42_720 VPWR VGND sg13g2_fill_2
XFILLER_41_252 VPWR VGND sg13g2_decap_8
XFILLER_5_186 VPWR VGND sg13g2_decap_8
XFILLER_45_7 VPWR VGND sg13g2_decap_8
X_1320_ VPWR _0118_ state\[91\] VGND sg13g2_inv_1
XFILLER_1_392 VPWR VGND sg13g2_decap_8
XFILLER_49_396 VPWR VGND sg13g2_decap_8
XFILLER_45_591 VPWR VGND sg13g2_fill_2
XFILLER_32_263 VPWR VGND sg13g2_decap_8
XFILLER_21_926 VPWR VGND sg13g2_fill_1
XFILLER_20_436 VPWR VGND sg13g2_decap_8
XFILLER_20_425 VPWR VGND sg13g2_fill_1
X_2498_ net249 VGND VPWR _0444_ state\[60\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1518_ VPWR _0169_ daisychain\[21\] VGND sg13g2_inv_1
X_1449_ VPWR _0245_ daisychain\[90\] VGND sg13g2_inv_1
XFILLER_11_403 VPWR VGND sg13g2_decap_8
XFILLER_23_263 VPWR VGND sg13g2_decap_8
XFILLER_23_11 VPWR VGND sg13g2_decap_8
XFILLER_23_88 VPWR VGND sg13g2_decap_8
XFILLER_3_635 VPWR VGND sg13g2_decap_8
XFILLER_2_123 VPWR VGND sg13g2_decap_8
XFILLER_48_63 VPWR VGND sg13g2_decap_8
XFILLER_47_801 VPWR VGND sg13g2_fill_1
XFILLER_46_322 VPWR VGND sg13g2_decap_8
XFILLER_46_399 VPWR VGND sg13g2_decap_8
XFILLER_42_550 VPWR VGND sg13g2_fill_1
XFILLER_30_701 VPWR VGND sg13g2_fill_2
XFILLER_14_263 VPWR VGND sg13g2_decap_8
XFILLER_9_46 VPWR VGND sg13g2_decap_8
X_2411__287 VPWR VGND net286 sg13g2_tiehi
XFILLER_10_491 VPWR VGND sg13g2_decap_8
XFILLER_6_440 VPWR VGND sg13g2_decap_8
X_2421_ net266 VGND VPWR _0367_ daisychain\[111\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2352_ net404 VGND VPWR _0298_ daisychain\[42\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2283_ VGND VPWR _0857_ _1012_ _0498_ net83 sg13g2_a21oi_1
X_1303_ VPWR _0009_ state\[108\] VGND sg13g2_inv_1
XFILLER_49_193 VPWR VGND sg13g2_decap_8
XFILLER_37_322 VPWR VGND sg13g2_decap_8
XFILLER_37_366 VPWR VGND sg13g2_fill_1
XFILLER_25_528 VPWR VGND sg13g2_fill_1
XFILLER_18_580 VPWR VGND sg13g2_decap_8
XFILLER_33_594 VPWR VGND sg13g2_fill_1
XFILLER_20_200 VPWR VGND sg13g2_decap_8
X_1998_ net215 VPWR _0856_ VGND state\[114\] net175 sg13g2_o21ai_1
XFILLER_20_277 VPWR VGND sg13g2_decap_8
XFILLER_0_616 VPWR VGND sg13g2_decap_8
XFILLER_47_119 VPWR VGND sg13g2_decap_8
XFILLER_28_333 VPWR VGND sg13g2_decap_8
XFILLER_18_11 VPWR VGND sg13g2_decap_8
XFILLER_44_815 VPWR VGND sg13g2_fill_1
XFILLER_44_837 VPWR VGND sg13g2_decap_4
XFILLER_18_88 VPWR VGND sg13g2_decap_8
XFILLER_43_336 VPWR VGND sg13g2_decap_8
XFILLER_34_32 VPWR VGND sg13g2_decap_8
XFILLER_11_200 VPWR VGND sg13g2_decap_8
XFILLER_11_277 VPWR VGND sg13g2_decap_8
XFILLER_7_259 VPWR VGND sg13g2_decap_8
XFILLER_3_410 VPWR VGND sg13g2_decap_8
XFILLER_3_487 VPWR VGND sg13g2_decap_8
XFILLER_1_0 VPWR VGND sg13g2_decap_8
X_2556__312 VPWR VGND net311 sg13g2_tiehi
XFILLER_38_119 VPWR VGND sg13g2_decap_8
XFILLER_19_333 VPWR VGND sg13g2_decap_8
XFILLER_46_196 VPWR VGND sg13g2_decap_8
XFILLER_34_347 VPWR VGND sg13g2_decap_8
X_1921_ VPWR VGND _0798_ net97 _0797_ _0249_ _0350_ net50 sg13g2_a221oi_1
XFILLER_30_531 VPWR VGND sg13g2_fill_1
X_1852_ VGND VPWR net160 daisychain\[76\] _0747_ net66 sg13g2_a21oi_1
X_2313__483 VPWR VGND net482 sg13g2_tiehi
XFILLER_30_586 VPWR VGND sg13g2_decap_8
X_1783_ net197 _0212_ _0694_ _0695_ VPWR VGND sg13g2_a21o_1
XFILLER_6_270 VPWR VGND sg13g2_decap_8
X_2404_ net300 VGND VPWR _0350_ daisychain\[94\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_2335_ net438 VGND VPWR _0281_ daisychain\[25\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2266_ _1004_ net132 state\[106\] VPWR VGND sg13g2_nand2_1
X_2197_ VGND VPWR _0728_ _0969_ _0455_ net111 sg13g2_a21oi_1
XFILLER_38_642 VPWR VGND sg13g2_decap_8
XFILLER_1_91 VPWR VGND sg13g2_decap_8
XFILLER_37_196 VPWR VGND sg13g2_decap_8
XFILLER_26_859 VPWR VGND sg13g2_fill_1
XFILLER_25_347 VPWR VGND sg13g2_decap_8
XFILLER_21_553 VPWR VGND sg13g2_fill_1
XFILLER_21_597 VPWR VGND sg13g2_fill_2
XFILLER_5_719 VPWR VGND sg13g2_decap_8
XFILLER_4_207 VPWR VGND sg13g2_decap_8
XFILLER_20_67 VPWR VGND sg13g2_decap_8
XFILLER_0_413 VPWR VGND sg13g2_decap_8
X_2364__381 VPWR VGND net380 sg13g2_tiehi
X_2395__319 VPWR VGND net318 sg13g2_tiehi
XFILLER_29_32 VPWR VGND sg13g2_decap_8
XFILLER_28_130 VPWR VGND sg13g2_decap_8
XFILLER_45_42 VPWR VGND sg13g2_decap_8
XFILLER_43_133 VPWR VGND sg13g2_decap_8
XFILLER_16_347 VPWR VGND sg13g2_decap_8
X_2482__314 VPWR VGND net313 sg13g2_tiehi
XFILLER_6_25 VPWR VGND sg13g2_decap_8
XANTENNA_7 VPWR VGND _0173_ sg13g2_antennanp
XFILLER_3_284 VPWR VGND sg13g2_decap_8
X_2120_ _0931_ net126 state\[33\] VPWR VGND sg13g2_nand2_1
X_2051_ net166 _0158_ _0895_ _0896_ VPWR VGND sg13g2_a21o_1
XFILLER_19_130 VPWR VGND sg13g2_decap_8
XFILLER_35_601 VPWR VGND sg13g2_decap_8
XFILLER_34_144 VPWR VGND sg13g2_decap_8
X_1904_ VGND VPWR net155 daisychain\[89\] _0786_ net60 sg13g2_a21oi_1
XFILLER_30_361 VPWR VGND sg13g2_decap_4
X_1835_ net202 _0226_ _0733_ _0734_ VPWR VGND sg13g2_a21o_1
X_1766_ net227 VPWR _0682_ VGND state\[56\] net199 sg13g2_o21ai_1
X_1697_ VPWR VGND _0630_ net74 _0629_ _0187_ _0294_ net27 sg13g2_a221oi_1
X_2318_ net472 VGND VPWR _0264_ daisychain\[8\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2249_ VGND VPWR _0806_ _0995_ _0481_ net96 sg13g2_a21oi_1
XFILLER_26_601 VPWR VGND sg13g2_fill_1
XFILLER_25_144 VPWR VGND sg13g2_decap_8
XFILLER_40_147 VPWR VGND sg13g2_decap_8
XFILLER_15_67 VPWR VGND sg13g2_decap_8
XFILLER_22_884 VPWR VGND sg13g2_fill_2
XFILLER_21_361 VPWR VGND sg13g2_decap_8
XFILLER_31_11 VPWR VGND sg13g2_decap_8
XFILLER_5_538 VPWR VGND sg13g2_decap_8
XFILLER_31_88 VPWR VGND sg13g2_decap_8
Xoutput11 net11 uio_out[3] VPWR VGND sg13g2_buf_1
Xoutput22 net22 uo_out[6] VPWR VGND sg13g2_buf_1
Xoutput9 net9 uio_out[1] VPWR VGND sg13g2_buf_1
XFILLER_0_210 VPWR VGND sg13g2_decap_8
XFILLER_0_287 VPWR VGND sg13g2_decap_8
XFILLER_49_759 VPWR VGND sg13g2_decap_8
XFILLER_48_203 VPWR VGND sg13g2_decap_8
XFILLER_29_461 VPWR VGND sg13g2_decap_8
XFILLER_16_144 VPWR VGND sg13g2_decap_8
XFILLER_31_158 VPWR VGND sg13g2_decap_8
XFILLER_12_361 VPWR VGND sg13g2_decap_8
XFILLER_8_354 VPWR VGND sg13g2_decap_8
X_1620_ VGND VPWR net123 daisychain\[18\] _0573_ net30 sg13g2_a21oi_1
X_1551_ net177 _0178_ _0520_ _0521_ VPWR VGND sg13g2_a21o_1
X_1482_ VPWR _0208_ daisychain\[57\] VGND sg13g2_inv_1
X_2558__248 VPWR VGND net247 sg13g2_tiehi
XFILLER_39_203 VPWR VGND sg13g2_decap_8
X_2103_ VGND VPWR _0587_ _0922_ _0408_ net93 sg13g2_a21oi_1
X_2034_ net210 VPWR _0883_ VGND state\[123\] net165 sg13g2_o21ai_1
XFILLER_47_280 VPWR VGND sg13g2_decap_8
XFILLER_35_486 VPWR VGND sg13g2_decap_4
XFILLER_22_158 VPWR VGND sg13g2_decap_8
X_1818_ net232 VPWR _0721_ VGND state\[69\] net205 sg13g2_o21ai_1
X_1749_ VPWR VGND _0669_ net102 _0668_ _0202_ _0307_ net54 sg13g2_a221oi_1
XFILLER_45_217 VPWR VGND sg13g2_decap_8
XFILLER_38_280 VPWR VGND sg13g2_decap_8
XFILLER_27_932 VPWR VGND sg13g2_fill_1
XFILLER_26_11 VPWR VGND sg13g2_decap_8
XFILLER_26_464 VPWR VGND sg13g2_fill_2
XFILLER_26_453 VPWR VGND sg13g2_decap_8
XFILLER_26_88 VPWR VGND sg13g2_decap_8
XFILLER_14_637 VPWR VGND sg13g2_fill_2
XFILLER_14_626 VPWR VGND sg13g2_decap_4
XFILLER_13_158 VPWR VGND sg13g2_decap_8
XFILLER_42_21 VPWR VGND sg13g2_decap_8
XFILLER_42_98 VPWR VGND sg13g2_decap_8
XFILLER_5_368 VPWR VGND sg13g2_decap_8
XFILLER_1_574 VPWR VGND sg13g2_decap_8
XFILLER_36_217 VPWR VGND sg13g2_decap_8
XFILLER_29_291 VPWR VGND sg13g2_decap_8
XFILLER_32_412 VPWR VGND sg13g2_decap_4
XFILLER_32_401 VPWR VGND sg13g2_decap_8
XFILLER_44_294 VPWR VGND sg13g2_decap_8
XFILLER_32_445 VPWR VGND sg13g2_fill_2
XFILLER_32_434 VPWR VGND sg13g2_decap_8
XFILLER_32_467 VPWR VGND sg13g2_decap_8
XFILLER_9_674 VPWR VGND sg13g2_decap_4
XFILLER_8_151 VPWR VGND sg13g2_decap_8
X_2564__296 VPWR VGND net295 sg13g2_tiehi
X_1603_ net168 _0162_ _0559_ _0560_ VPWR VGND sg13g2_a21o_1
X_1534_ VPWR _0211_ daisychain\[5\] VGND sg13g2_inv_1
XFILLER_5_880 VPWR VGND sg13g2_fill_2
Xfanout119 net146 net119 VPWR VGND sg13g2_buf_1
Xfanout108 net109 net108 VPWR VGND sg13g2_buf_1
X_2421__267 VPWR VGND net266 sg13g2_tiehi
X_1465_ VPWR _0227_ daisychain\[74\] VGND sg13g2_inv_1
X_1396_ VPWR _0034_ state\[15\] VGND sg13g2_inv_1
XFILLER_27_217 VPWR VGND sg13g2_decap_8
X_2017_ VPWR VGND _0870_ net89 _0869_ _0148_ _0374_ net43 sg13g2_a221oi_1
XFILLER_35_294 VPWR VGND sg13g2_decap_8
XFILLER_23_434 VPWR VGND sg13g2_decap_8
XFILLER_23_467 VPWR VGND sg13g2_decap_8
XFILLER_12_46 VPWR VGND sg13g2_decap_8
XFILLER_3_817 VPWR VGND sg13g2_decap_8
XFILLER_2_305 VPWR VGND sg13g2_decap_8
X_2443__470 VPWR VGND net469 sg13g2_tiehi
XFILLER_37_21 VPWR VGND sg13g2_decap_8
XFILLER_19_718 VPWR VGND sg13g2_decap_4
XFILLER_18_228 VPWR VGND sg13g2_decap_8
XFILLER_37_98 VPWR VGND sg13g2_decap_8
XFILLER_41_231 VPWR VGND sg13g2_decap_8
XFILLER_14_478 VPWR VGND sg13g2_decap_8
XFILLER_6_688 VPWR VGND sg13g2_fill_1
XFILLER_5_165 VPWR VGND sg13g2_decap_8
XFILLER_38_7 VPWR VGND sg13g2_decap_8
XFILLER_1_371 VPWR VGND sg13g2_decap_8
XFILLER_49_375 VPWR VGND sg13g2_decap_8
XFILLER_21_905 VPWR VGND sg13g2_fill_1
XFILLER_17_294 VPWR VGND sg13g2_decap_8
XFILLER_32_242 VPWR VGND sg13g2_decap_8
XFILLER_20_404 VPWR VGND sg13g2_decap_8
XFILLER_0_809 VPWR VGND sg13g2_fill_1
X_2497_ net253 VGND VPWR _0443_ state\[59\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1517_ VPWR _0170_ daisychain\[22\] VGND sg13g2_inv_1
X_2323__463 VPWR VGND net462 sg13g2_tiehi
X_1448_ VPWR _0246_ daisychain\[91\] VGND sg13g2_inv_1
X_1379_ VPWR _0053_ state\[32\] VGND sg13g2_inv_1
XFILLER_23_242 VPWR VGND sg13g2_decap_8
XFILLER_11_459 VPWR VGND sg13g2_decap_8
XFILLER_23_67 VPWR VGND sg13g2_decap_8
XFILLER_2_102 VPWR VGND sg13g2_decap_8
XFILLER_3_658 VPWR VGND sg13g2_fill_2
XFILLER_3_647 VPWR VGND sg13g2_decap_8
XFILLER_3_4 VPWR VGND sg13g2_decap_8
XFILLER_2_179 VPWR VGND sg13g2_decap_8
X_2478__330 VPWR VGND net329 sg13g2_tiehi
XFILLER_48_42 VPWR VGND sg13g2_decap_8
XFILLER_46_301 VPWR VGND sg13g2_decap_8
XFILLER_19_537 VPWR VGND sg13g2_fill_1
XFILLER_0_49 VPWR VGND sg13g2_decap_8
X_2374__361 VPWR VGND net360 sg13g2_tiehi
XFILLER_46_378 VPWR VGND sg13g2_decap_8
XFILLER_9_25 VPWR VGND sg13g2_decap_8
XFILLER_14_242 VPWR VGND sg13g2_decap_8
Xfanout90 net99 net90 VPWR VGND sg13g2_buf_1
XFILLER_10_470 VPWR VGND sg13g2_decap_8
X_2420_ net268 VGND VPWR _0366_ daisychain\[110\] clknet_leaf_5_clk sg13g2_dfrbpq_1
XFILLER_6_496 VPWR VGND sg13g2_decap_8
X_2351_ net406 VGND VPWR _0297_ daisychain\[41\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2282_ _1012_ net130 state\[114\] VPWR VGND sg13g2_nand2_1
X_1302_ VPWR _0010_ state\[109\] VGND sg13g2_inv_1
X_2457__414 VPWR VGND net413 sg13g2_tiehi
XFILLER_49_172 VPWR VGND sg13g2_decap_8
XFILLER_37_301 VPWR VGND sg13g2_decap_8
X_1997_ VPWR VGND _0855_ net82 _0854_ _0143_ _0369_ net36 sg13g2_a221oi_1
XFILLER_21_757 VPWR VGND sg13g2_decap_8
XFILLER_20_256 VPWR VGND sg13g2_decap_8
X_2549_ net255 VGND VPWR _0495_ state\[111\] clknet_leaf_4_clk sg13g2_dfrbpq_1
XFILLER_28_312 VPWR VGND sg13g2_decap_8
XFILLER_18_67 VPWR VGND sg13g2_decap_8
XFILLER_43_315 VPWR VGND sg13g2_decap_8
XFILLER_34_11 VPWR VGND sg13g2_decap_8
XFILLER_24_551 VPWR VGND sg13g2_fill_2
XFILLER_34_88 VPWR VGND sg13g2_decap_8
XFILLER_11_256 VPWR VGND sg13g2_decap_8
XFILLER_7_238 VPWR VGND sg13g2_decap_8
XFILLER_4_989 VPWR VGND sg13g2_decap_8
XFILLER_3_466 VPWR VGND sg13g2_decap_8
XFILLER_47_621 VPWR VGND sg13g2_decap_4
XFILLER_19_312 VPWR VGND sg13g2_decap_8
XFILLER_47_654 VPWR VGND sg13g2_decap_8
XFILLER_46_175 VPWR VGND sg13g2_decap_8
XFILLER_34_326 VPWR VGND sg13g2_decap_8
X_1920_ VGND VPWR net144 daisychain\[93\] _0798_ net49 sg13g2_a21oi_1
X_1851_ net205 _0230_ _0745_ _0746_ VPWR VGND sg13g2_a21o_1
X_1782_ net227 VPWR _0694_ VGND state\[60\] net197 sg13g2_o21ai_1
X_2403_ net302 VGND VPWR _0349_ daisychain\[93\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2334_ net440 VGND VPWR _0280_ daisychain\[24\] clknet_leaf_8_clk sg13g2_dfrbpq_1
XFILLER_29_109 VPWR VGND sg13g2_decap_8
XFILLER_27_0 VPWR VGND sg13g2_decap_8
X_2265_ VGND VPWR _0830_ _1003_ _0489_ net85 sg13g2_a21oi_1
X_2196_ _0969_ net158 state\[71\] VPWR VGND sg13g2_nand2_1
XFILLER_37_175 VPWR VGND sg13g2_decap_8
XFILLER_1_70 VPWR VGND sg13g2_decap_8
XFILLER_25_326 VPWR VGND sg13g2_decap_8
XFILLER_40_329 VPWR VGND sg13g2_decap_8
XFILLER_21_532 VPWR VGND sg13g2_decap_8
XFILLER_20_46 VPWR VGND sg13g2_decap_8
XFILLER_29_11 VPWR VGND sg13g2_decap_8
XFILLER_0_469 VPWR VGND sg13g2_decap_8
XFILLER_48_429 VPWR VGND sg13g2_decap_8
XFILLER_29_88 VPWR VGND sg13g2_decap_8
XFILLER_21_1025 VPWR VGND sg13g2_decap_4
XFILLER_21_1003 VPWR VGND sg13g2_fill_1
XFILLER_45_21 VPWR VGND sg13g2_decap_8
XFILLER_44_613 VPWR VGND sg13g2_fill_1
XFILLER_43_112 VPWR VGND sg13g2_decap_8
XFILLER_28_186 VPWR VGND sg13g2_decap_8
XFILLER_16_326 VPWR VGND sg13g2_decap_8
XFILLER_45_98 VPWR VGND sg13g2_decap_8
XFILLER_43_189 VPWR VGND sg13g2_decap_8
XFILLER_24_392 VPWR VGND sg13g2_fill_1
XFILLER_8_536 VPWR VGND sg13g2_fill_1
XANTENNA_8 VPWR VGND _0175_ sg13g2_antennanp
XFILLER_3_263 VPWR VGND sg13g2_decap_8
XFILLER_4_797 VPWR VGND sg13g2_fill_1
X_2050_ net209 VPWR _0895_ VGND state\[127\] net166 sg13g2_o21ai_1
XFILLER_47_462 VPWR VGND sg13g2_decap_8
XFILLER_47_495 VPWR VGND sg13g2_decap_8
XFILLER_34_123 VPWR VGND sg13g2_decap_8
XFILLER_19_186 VPWR VGND sg13g2_decap_8
XFILLER_35_668 VPWR VGND sg13g2_fill_1
XFILLER_43_690 VPWR VGND sg13g2_fill_2
X_1903_ net203 _0245_ _0784_ _0785_ VPWR VGND sg13g2_a21o_1
XFILLER_30_340 VPWR VGND sg13g2_decap_8
X_1834_ net231 VPWR _0733_ VGND state\[73\] net202 sg13g2_o21ai_1
X_1765_ VPWR VGND _0681_ net105 _0680_ _0206_ _0311_ net56 sg13g2_a221oi_1
X_1696_ VGND VPWR net120 daisychain\[37\] _0630_ net27 sg13g2_a21oi_1
XFILLER_44_1025 VPWR VGND sg13g2_decap_4
X_2317_ net474 VGND VPWR _0263_ daisychain\[7\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2248_ _0995_ net143 state\[97\] VPWR VGND sg13g2_nand2_1
XFILLER_38_440 VPWR VGND sg13g2_fill_1
X_2179_ VGND VPWR _0701_ _0960_ _0446_ net105 sg13g2_a21oi_1
XFILLER_26_624 VPWR VGND sg13g2_fill_1
XFILLER_25_123 VPWR VGND sg13g2_decap_8
X_2431__247 VPWR VGND net246 sg13g2_tiehi
XFILLER_41_649 VPWR VGND sg13g2_decap_8
XFILLER_40_126 VPWR VGND sg13g2_decap_8
XFILLER_15_46 VPWR VGND sg13g2_decap_8
XFILLER_21_340 VPWR VGND sg13g2_decap_8
XFILLER_5_517 VPWR VGND sg13g2_decap_8
XFILLER_31_67 VPWR VGND sg13g2_decap_8
Xoutput12 net12 uio_out[4] VPWR VGND sg13g2_buf_1
Xoutput23 net23 uo_out[7] VPWR VGND sg13g2_buf_1
XFILLER_0_266 VPWR VGND sg13g2_decap_8
XFILLER_48_259 VPWR VGND sg13g2_decap_8
XFILLER_29_440 VPWR VGND sg13g2_fill_2
XFILLER_16_123 VPWR VGND sg13g2_decap_8
XFILLER_32_627 VPWR VGND sg13g2_fill_2
XFILLER_32_616 VPWR VGND sg13g2_fill_2
XFILLER_31_137 VPWR VGND sg13g2_decap_8
XFILLER_12_340 VPWR VGND sg13g2_decap_8
XFILLER_8_333 VPWR VGND sg13g2_decap_8
XFILLER_40_682 VPWR VGND sg13g2_decap_8
X_1550_ net216 VPWR _0520_ VGND state\[2\] net177 sg13g2_o21ai_1
X_1481_ VPWR _0209_ daisychain\[58\] VGND sg13g2_inv_1
X_2102_ _0922_ net140 state\[24\] VPWR VGND sg13g2_nand2_1
XFILLER_39_259 VPWR VGND sg13g2_decap_8
X_2033_ VPWR VGND _0882_ net71 _0881_ _0153_ _0378_ net25 sg13g2_a221oi_1
XFILLER_22_137 VPWR VGND sg13g2_decap_8
X_1817_ VPWR VGND _0720_ net113 _0719_ _0220_ _0324_ net67 sg13g2_a221oi_1
XFILLER_7_91 VPWR VGND sg13g2_decap_8
X_1748_ VGND VPWR net149 daisychain\[50\] _0669_ net54 sg13g2_a21oi_1
XFILLER_2_509 VPWR VGND sg13g2_decap_8
X_1679_ net172 _0183_ _0616_ _0617_ VPWR VGND sg13g2_a21o_1
XFILLER_26_432 VPWR VGND sg13g2_decap_8
XFILLER_41_402 VPWR VGND sg13g2_decap_8
XFILLER_26_67 VPWR VGND sg13g2_decap_8
XFILLER_13_137 VPWR VGND sg13g2_decap_8
X_2333__443 VPWR VGND net442 sg13g2_tiehi
XFILLER_42_77 VPWR VGND sg13g2_decap_8
XFILLER_5_347 VPWR VGND sg13g2_decap_8
X_2520__348 VPWR VGND net347 sg13g2_tiehi
XFILLER_1_553 VPWR VGND sg13g2_decap_8
XFILLER_49_513 VPWR VGND sg13g2_decap_8
XFILLER_37_719 VPWR VGND sg13g2_fill_1
XFILLER_29_270 VPWR VGND sg13g2_decap_8
XFILLER_44_273 VPWR VGND sg13g2_decap_8
XFILLER_17_487 VPWR VGND sg13g2_fill_1
XFILLER_8_130 VPWR VGND sg13g2_decap_8
X_1602_ net211 VPWR _0559_ VGND state\[15\] net168 sg13g2_o21ai_1
X_2384__341 VPWR VGND net340 sg13g2_tiehi
X_1533_ VPWR _0222_ daisychain\[6\] VGND sg13g2_inv_1
Xfanout109 net110 net109 VPWR VGND sg13g2_buf_1
X_1464_ VPWR _0228_ daisychain\[75\] VGND sg13g2_inv_1
X_1395_ VPWR _0035_ state\[16\] VGND sg13g2_inv_1
X_2016_ VGND VPWR net136 daisychain\[117\] _0870_ net43 sg13g2_a21oi_1
XFILLER_35_273 VPWR VGND sg13g2_decap_8
XFILLER_24_969 VPWR VGND sg13g2_fill_1
XFILLER_12_25 VPWR VGND sg13g2_decap_8
XFILLER_3_807 VPWR VGND sg13g2_fill_2
XFILLER_18_207 VPWR VGND sg13g2_decap_8
XFILLER_37_77 VPWR VGND sg13g2_decap_8
XFILLER_27_741 VPWR VGND sg13g2_decap_8
XFILLER_42_722 VPWR VGND sg13g2_fill_1
XFILLER_27_796 VPWR VGND sg13g2_decap_8
X_2450__442 VPWR VGND net441 sg13g2_tiehi
XFILLER_41_210 VPWR VGND sg13g2_decap_8
XFILLER_26_284 VPWR VGND sg13g2_decap_8
XFILLER_14_424 VPWR VGND sg13g2_decap_8
XFILLER_14_468 VPWR VGND sg13g2_fill_2
XFILLER_41_287 VPWR VGND sg13g2_decap_8
XFILLER_10_641 VPWR VGND sg13g2_decap_8
XFILLER_10_663 VPWR VGND sg13g2_fill_2
XFILLER_5_144 VPWR VGND sg13g2_decap_8
XFILLER_1_350 VPWR VGND sg13g2_decap_8
XFILLER_49_354 VPWR VGND sg13g2_decap_8
XFILLER_37_549 VPWR VGND sg13g2_fill_1
XFILLER_17_273 VPWR VGND sg13g2_decap_8
XFILLER_45_593 VPWR VGND sg13g2_fill_1
XFILLER_32_221 VPWR VGND sg13g2_decap_8
XFILLER_21_939 VPWR VGND sg13g2_fill_1
XFILLER_32_298 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_12_clk clknet_2_2__leaf_clk clknet_leaf_12_clk VPWR VGND sg13g2_buf_8
XFILLER_9_494 VPWR VGND sg13g2_decap_8
X_2565_ net359 VGND VPWR _0511_ state\[127\] clknet_leaf_18_clk sg13g2_dfrbpq_1
X_1516_ VPWR _0171_ daisychain\[23\] VGND sg13g2_inv_1
X_2496_ net257 VGND VPWR _0442_ state\[58\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1447_ VPWR _0247_ daisychain\[92\] VGND sg13g2_inv_1
XFILLER_4_81 VPWR VGND sg13g2_decap_8
X_1378_ VPWR _0054_ state\[33\] VGND sg13g2_inv_1
XFILLER_28_527 VPWR VGND sg13g2_decap_8
XFILLER_43_519 VPWR VGND sg13g2_decap_4
XFILLER_36_582 VPWR VGND sg13g2_decap_8
XFILLER_23_221 VPWR VGND sg13g2_decap_8
XFILLER_24_788 VPWR VGND sg13g2_fill_2
XFILLER_11_438 VPWR VGND sg13g2_decap_8
XFILLER_23_46 VPWR VGND sg13g2_decap_8
XFILLER_23_298 VPWR VGND sg13g2_decap_8
XFILLER_7_409 VPWR VGND sg13g2_decap_8
XFILLER_2_158 VPWR VGND sg13g2_decap_8
XFILLER_48_21 VPWR VGND sg13g2_decap_8
XFILLER_19_505 VPWR VGND sg13g2_fill_1
XFILLER_48_98 VPWR VGND sg13g2_decap_8
XFILLER_0_28 VPWR VGND sg13g2_decap_8
XFILLER_46_357 VPWR VGND sg13g2_decap_8
XFILLER_34_508 VPWR VGND sg13g2_decap_8
XFILLER_19_549 VPWR VGND sg13g2_decap_4
XFILLER_27_571 VPWR VGND sg13g2_fill_1
XFILLER_14_221 VPWR VGND sg13g2_decap_8
XFILLER_42_574 VPWR VGND sg13g2_fill_2
X_2485__302 VPWR VGND net301 sg13g2_tiehi
XFILLER_14_298 VPWR VGND sg13g2_decap_8
Xfanout80 net81 net80 VPWR VGND sg13g2_buf_1
Xfanout91 net94 net91 VPWR VGND sg13g2_buf_1
XFILLER_6_475 VPWR VGND sg13g2_decap_8
X_2350_ net408 VGND VPWR _0296_ daisychain\[40\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2281_ VGND VPWR _0854_ _1011_ _0497_ net82 sg13g2_a21oi_1
X_1301_ VPWR _0012_ state\[110\] VGND sg13g2_inv_1
Xclkbuf_leaf_1_clk clknet_2_2__leaf_clk clknet_leaf_1_clk VPWR VGND sg13g2_buf_8
XFILLER_29_4 VPWR VGND sg13g2_decap_8
XFILLER_49_151 VPWR VGND sg13g2_decap_8
XFILLER_37_357 VPWR VGND sg13g2_decap_8
XFILLER_33_585 VPWR VGND sg13g2_decap_8
XFILLER_21_747 VPWR VGND sg13g2_fill_2
X_1996_ VGND VPWR net129 daisychain\[112\] _0855_ net36 sg13g2_a21oi_1
XFILLER_20_235 VPWR VGND sg13g2_decap_8
XFILLER_9_291 VPWR VGND sg13g2_decap_8
X_2548_ net271 VGND VPWR _0494_ state\[110\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2479_ net325 VGND VPWR _0425_ state\[41\] clknet_leaf_12_clk sg13g2_dfrbpq_1
XFILLER_18_46 VPWR VGND sg13g2_decap_8
XFILLER_34_67 VPWR VGND sg13g2_decap_8
XFILLER_11_235 VPWR VGND sg13g2_decap_8
XFILLER_8_718 VPWR VGND sg13g2_fill_2
Xclkload0 clknet_2_3__leaf_clk clkload0/X VPWR VGND sg13g2_buf_8
XFILLER_7_217 VPWR VGND sg13g2_decap_8
XFILLER_4_913 VPWR VGND sg13g2_decap_8
XFILLER_4_968 VPWR VGND sg13g2_fill_1
XFILLER_3_445 VPWR VGND sg13g2_decap_8
XFILLER_46_154 VPWR VGND sg13g2_decap_8
XFILLER_34_305 VPWR VGND sg13g2_decap_8
XFILLER_19_368 VPWR VGND sg13g2_decap_8
XFILLER_15_552 VPWR VGND sg13g2_fill_2
XFILLER_15_541 VPWR VGND sg13g2_fill_2
X_1850_ net232 VPWR _0745_ VGND state\[77\] net205 sg13g2_o21ai_1
X_1781_ VPWR VGND _0693_ net111 _0692_ _0210_ _0315_ net57 sg13g2_a221oi_1
XFILLER_30_566 VPWR VGND sg13g2_fill_1
X_2402_ net304 VGND VPWR _0348_ daisychain\[92\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2333_ net442 VGND VPWR _0279_ daisychain\[23\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2264_ _1003_ net132 state\[105\] VPWR VGND sg13g2_nand2_1
X_2195_ VGND VPWR _0725_ _0968_ _0454_ net112 sg13g2_a21oi_1
XFILLER_37_154 VPWR VGND sg13g2_decap_8
XFILLER_25_305 VPWR VGND sg13g2_decap_8
X_2511__420 VPWR VGND net419 sg13g2_tiehi
XFILLER_40_308 VPWR VGND sg13g2_decap_8
X_1979_ net180 _0138_ _0841_ _0842_ VPWR VGND sg13g2_a21o_1
XFILLER_20_25 VPWR VGND sg13g2_decap_8
XFILLER_0_448 VPWR VGND sg13g2_decap_8
XFILLER_48_408 VPWR VGND sg13g2_decap_8
XFILLER_29_67 VPWR VGND sg13g2_decap_8
XFILLER_29_600 VPWR VGND sg13g2_fill_1
XFILLER_28_165 VPWR VGND sg13g2_decap_8
XFILLER_16_305 VPWR VGND sg13g2_decap_8
XFILLER_44_625 VPWR VGND sg13g2_fill_2
XFILLER_45_77 VPWR VGND sg13g2_decap_8
XFILLER_43_168 VPWR VGND sg13g2_decap_8
XFILLER_31_319 VPWR VGND sg13g2_decap_8
XFILLER_12_588 VPWR VGND sg13g2_decap_8
XFILLER_8_515 VPWR VGND sg13g2_decap_8
XFILLER_12_599 VPWR VGND sg13g2_fill_1
XANTENNA_9 VPWR VGND _0175_ sg13g2_antennanp
X_2523__324 VPWR VGND net323 sg13g2_tiehi
X_2343__423 VPWR VGND net422 sg13g2_tiehi
XFILLER_4_754 VPWR VGND sg13g2_decap_8
XFILLER_3_242 VPWR VGND sg13g2_decap_8
XFILLER_47_441 VPWR VGND sg13g2_decap_8
XFILLER_48_986 VPWR VGND sg13g2_fill_2
XFILLER_19_165 VPWR VGND sg13g2_decap_8
XFILLER_34_102 VPWR VGND sg13g2_decap_8
XFILLER_34_179 VPWR VGND sg13g2_decap_8
XFILLER_22_319 VPWR VGND sg13g2_decap_8
X_1902_ net230 VPWR _0784_ VGND state\[90\] net203 sg13g2_o21ai_1
XFILLER_15_382 VPWR VGND sg13g2_decap_8
X_1833_ VPWR VGND _0732_ net111 _0731_ _0225_ _0328_ net64 sg13g2_a221oi_1
X_1764_ VGND VPWR net152 daisychain\[54\] _0681_ net56 sg13g2_a21oi_1
X_1695_ net169 _0187_ _0628_ _0629_ VPWR VGND sg13g2_a21o_1
X_2316_ net476 VGND VPWR _0262_ daisychain\[6\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2247_ VGND VPWR _0803_ _0994_ _0480_ net95 sg13g2_a21oi_1
X_2394__321 VPWR VGND net320 sg13g2_tiehi
XFILLER_38_452 VPWR VGND sg13g2_fill_1
X_2178_ _0960_ net152 state\[62\] VPWR VGND sg13g2_nand2_1
XFILLER_25_102 VPWR VGND sg13g2_decap_8
XFILLER_13_319 VPWR VGND sg13g2_decap_8
XFILLER_41_628 VPWR VGND sg13g2_fill_2
XFILLER_40_105 VPWR VGND sg13g2_decap_8
XFILLER_25_179 VPWR VGND sg13g2_decap_8
XFILLER_15_25 VPWR VGND sg13g2_decap_8
XFILLER_22_831 VPWR VGND sg13g2_fill_2
XFILLER_31_46 VPWR VGND sg13g2_decap_8
Xoutput13 net13 uio_out[5] VPWR VGND sg13g2_buf_1
XFILLER_0_245 VPWR VGND sg13g2_decap_8
XFILLER_49_739 VPWR VGND sg13g2_decap_8
XFILLER_48_238 VPWR VGND sg13g2_decap_8
XFILLER_29_485 VPWR VGND sg13g2_decap_8
XFILLER_16_102 VPWR VGND sg13g2_decap_8
XFILLER_44_488 VPWR VGND sg13g2_decap_8
XFILLER_31_116 VPWR VGND sg13g2_decap_8
XFILLER_25_680 VPWR VGND sg13g2_fill_1
XFILLER_16_179 VPWR VGND sg13g2_decap_8
XFILLER_8_312 VPWR VGND sg13g2_decap_8
XFILLER_12_396 VPWR VGND sg13g2_decap_8
X_2310__488 VPWR VGND net487 sg13g2_tiehi
XFILLER_8_389 VPWR VGND sg13g2_decap_8
X_1480_ VPWR _0210_ daisychain\[59\] VGND sg13g2_inv_1
XFILLER_4_573 VPWR VGND sg13g2_decap_8
X_2101_ VGND VPWR _0584_ _0921_ _0407_ net93 sg13g2_a21oi_1
XFILLER_39_238 VPWR VGND sg13g2_decap_8
XFILLER_11_4 VPWR VGND sg13g2_decap_8
X_2032_ VGND VPWR net116 daisychain\[121\] _0882_ net26 sg13g2_a21oi_1
XFILLER_35_422 VPWR VGND sg13g2_fill_1
XFILLER_35_411 VPWR VGND sg13g2_decap_8
XFILLER_35_400 VPWR VGND sg13g2_fill_2
XFILLER_22_116 VPWR VGND sg13g2_decap_8
XFILLER_31_683 VPWR VGND sg13g2_decap_8
X_1816_ VGND VPWR net161 daisychain\[67\] _0720_ net67 sg13g2_a21oi_1
XFILLER_30_193 VPWR VGND sg13g2_decap_8
XFILLER_7_70 VPWR VGND sg13g2_decap_8
X_1747_ net196 _0202_ _0667_ _0668_ VPWR VGND sg13g2_a21o_1
X_1678_ net212 VPWR _0616_ VGND state\[34\] net172 sg13g2_o21ai_1
XFILLER_26_46 VPWR VGND sg13g2_decap_8
XFILLER_14_639 VPWR VGND sg13g2_fill_1
XFILLER_14_606 VPWR VGND sg13g2_fill_2
XFILLER_13_116 VPWR VGND sg13g2_decap_8
XFILLER_9_109 VPWR VGND sg13g2_decap_8
XFILLER_42_56 VPWR VGND sg13g2_decap_8
XFILLER_21_193 VPWR VGND sg13g2_decap_8
XFILLER_5_326 VPWR VGND sg13g2_decap_8
XFILLER_1_532 VPWR VGND sg13g2_decap_8
XFILLER_3_39 VPWR VGND sg13g2_decap_8
XFILLER_49_547 VPWR VGND sg13g2_decap_8
XFILLER_17_411 VPWR VGND sg13g2_fill_2
XFILLER_17_400 VPWR VGND sg13g2_decap_8
XFILLER_44_252 VPWR VGND sg13g2_decap_8
XFILLER_32_447 VPWR VGND sg13g2_fill_1
XFILLER_17_499 VPWR VGND sg13g2_decap_4
XFILLER_13_661 VPWR VGND sg13g2_decap_8
XFILLER_12_193 VPWR VGND sg13g2_decap_8
X_1601_ VPWR VGND _0558_ net75 _0557_ _0161_ _0270_ net29 sg13g2_a221oi_1
XFILLER_8_186 VPWR VGND sg13g2_decap_8
XFILLER_5_860 VPWR VGND sg13g2_fill_1
X_1532_ VPWR _0233_ daisychain\[7\] VGND sg13g2_inv_1
XFILLER_5_893 VPWR VGND sg13g2_fill_1
X_1463_ VPWR _0229_ daisychain\[76\] VGND sg13g2_inv_1
X_1394_ VPWR _0036_ state\[17\] VGND sg13g2_inv_1
X_2015_ net181 _0148_ _0868_ _0869_ VPWR VGND sg13g2_a21o_1
XFILLER_35_252 VPWR VGND sg13g2_decap_8
XFILLER_24_948 VPWR VGND sg13g2_decap_8
XFILLER_31_491 VPWR VGND sg13g2_decap_8
X_2400__309 VPWR VGND net308 sg13g2_tiehi
XFILLER_37_56 VPWR VGND sg13g2_decap_8
XFILLER_2_1023 VPWR VGND sg13g2_decap_4
XFILLER_2_1001 VPWR VGND sg13g2_fill_2
XFILLER_27_720 VPWR VGND sg13g2_fill_1
XFILLER_26_263 VPWR VGND sg13g2_decap_8
XFILLER_14_403 VPWR VGND sg13g2_decap_8
XFILLER_14_447 VPWR VGND sg13g2_decap_8
XFILLER_41_266 VPWR VGND sg13g2_decap_8
XFILLER_6_602 VPWR VGND sg13g2_decap_8
XFILLER_6_679 VPWR VGND sg13g2_decap_8
XFILLER_5_123 VPWR VGND sg13g2_decap_8
XFILLER_2_830 VPWR VGND sg13g2_fill_1
XFILLER_49_333 VPWR VGND sg13g2_decap_8
XFILLER_37_517 VPWR VGND sg13g2_decap_8
XFILLER_45_561 VPWR VGND sg13g2_decap_4
XFILLER_17_252 VPWR VGND sg13g2_decap_8
XFILLER_32_200 VPWR VGND sg13g2_decap_8
XFILLER_21_918 VPWR VGND sg13g2_fill_1
XFILLER_32_277 VPWR VGND sg13g2_decap_8
XFILLER_9_473 VPWR VGND sg13g2_decap_8
X_2564_ net295 VGND VPWR _0510_ state\[126\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_1515_ VPWR _0172_ daisychain\[24\] VGND sg13g2_inv_1
X_2495_ net261 VGND VPWR _0441_ state\[57\] clknet_leaf_14_clk sg13g2_dfrbpq_1
XFILLER_4_60 VPWR VGND sg13g2_decap_8
X_1446_ VPWR _0248_ daisychain\[93\] VGND sg13g2_inv_1
X_1377_ VPWR _0055_ state\[34\] VGND sg13g2_inv_1
XFILLER_23_200 VPWR VGND sg13g2_decap_8
XFILLER_11_417 VPWR VGND sg13g2_decap_8
XFILLER_23_277 VPWR VGND sg13g2_decap_8
XFILLER_23_25 VPWR VGND sg13g2_decap_8
XFILLER_3_605 VPWR VGND sg13g2_fill_2
XFILLER_2_137 VPWR VGND sg13g2_decap_8
XFILLER_24_1024 VPWR VGND sg13g2_decap_4
XFILLER_48_77 VPWR VGND sg13g2_decap_8
XFILLER_19_528 VPWR VGND sg13g2_decap_8
XFILLER_46_336 VPWR VGND sg13g2_decap_8
XFILLER_27_550 VPWR VGND sg13g2_decap_8
XFILLER_15_712 VPWR VGND sg13g2_fill_2
XFILLER_27_583 VPWR VGND sg13g2_decap_8
XFILLER_14_200 VPWR VGND sg13g2_decap_8
XFILLER_14_277 VPWR VGND sg13g2_decap_8
Xfanout70 net81 net70 VPWR VGND sg13g2_buf_1
Xfanout81 net99 net81 VPWR VGND sg13g2_buf_1
Xfanout92 net94 net92 VPWR VGND sg13g2_buf_1
X_2526__300 VPWR VGND net299 sg13g2_tiehi
X_2565__360 VPWR VGND net359 sg13g2_tiehi
XFILLER_6_454 VPWR VGND sg13g2_decap_8
XFILLER_43_7 VPWR VGND sg13g2_decap_8
X_2280_ _1011_ net129 state\[113\] VPWR VGND sg13g2_nand2_1
X_1300_ VPWR _0013_ state\[111\] VGND sg13g2_inv_1
XFILLER_49_130 VPWR VGND sg13g2_decap_8
XFILLER_37_336 VPWR VGND sg13g2_decap_8
X_2353__403 VPWR VGND net402 sg13g2_tiehi
XFILLER_18_594 VPWR VGND sg13g2_fill_1
XFILLER_21_704 VPWR VGND sg13g2_fill_1
XFILLER_20_214 VPWR VGND sg13g2_decap_8
X_1995_ net175 _0143_ _0853_ _0854_ VPWR VGND sg13g2_a21o_1
XFILLER_9_270 VPWR VGND sg13g2_decap_8
X_2547_ net287 VGND VPWR _0493_ state\[109\] clknet_leaf_5_clk sg13g2_dfrbpq_1
XFILLER_47_1024 VPWR VGND sg13g2_decap_4
X_2478_ net329 VGND VPWR _0424_ state\[40\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_1429_ VPWR _0140_ daisychain\[110\] VGND sg13g2_inv_1
XFILLER_18_25 VPWR VGND sg13g2_decap_8
XFILLER_28_347 VPWR VGND sg13g2_decap_8
XFILLER_34_46 VPWR VGND sg13g2_decap_8
XFILLER_11_214 VPWR VGND sg13g2_decap_8
Xclkload1 clkload1/Y clknet_leaf_2_clk VPWR VGND sg13g2_inv_2
XFILLER_3_424 VPWR VGND sg13g2_decap_8
XFILLER_46_133 VPWR VGND sg13g2_decap_8
XFILLER_19_347 VPWR VGND sg13g2_decap_8
XFILLER_42_361 VPWR VGND sg13g2_fill_1
XFILLER_42_350 VPWR VGND sg13g2_decap_8
X_1780_ VGND VPWR net158 daisychain\[58\] _0693_ net64 sg13g2_a21oi_1
XFILLER_10_291 VPWR VGND sg13g2_decap_8
XFILLER_6_284 VPWR VGND sg13g2_decap_8
X_2401_ net306 VGND VPWR _0347_ daisychain\[91\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2332_ net444 VGND VPWR _0278_ daisychain\[22\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2263_ VGND VPWR _0827_ _1002_ _0488_ net88 sg13g2_a21oi_1
X_2194_ _0968_ net160 state\[70\] VPWR VGND sg13g2_nand2_1
XFILLER_37_133 VPWR VGND sg13g2_decap_8
XFILLER_33_361 VPWR VGND sg13g2_decap_8
X_1978_ net217 VPWR _0841_ VGND state\[109\] net180 sg13g2_o21ai_1
XFILLER_0_427 VPWR VGND sg13g2_decap_8
XFILLER_29_46 VPWR VGND sg13g2_decap_8
XFILLER_29_634 VPWR VGND sg13g2_fill_1
XFILLER_29_623 VPWR VGND sg13g2_decap_8
XFILLER_29_689 VPWR VGND sg13g2_decap_8
XFILLER_29_667 VPWR VGND sg13g2_fill_2
XFILLER_28_144 VPWR VGND sg13g2_decap_8
XFILLER_45_56 VPWR VGND sg13g2_decap_8
XFILLER_44_659 VPWR VGND sg13g2_fill_2
XFILLER_43_147 VPWR VGND sg13g2_decap_8
XFILLER_12_512 VPWR VGND sg13g2_decap_8
XFILLER_24_372 VPWR VGND sg13g2_fill_2
XFILLER_24_361 VPWR VGND sg13g2_decap_8
XFILLER_12_534 VPWR VGND sg13g2_decap_8
XFILLER_12_545 VPWR VGND sg13g2_fill_1
XFILLER_6_39 VPWR VGND sg13g2_decap_8
XFILLER_3_221 VPWR VGND sg13g2_decap_8
XFILLER_10_81 VPWR VGND sg13g2_decap_8
XFILLER_3_298 VPWR VGND sg13g2_decap_8
XFILLER_47_420 VPWR VGND sg13g2_decap_8
XFILLER_19_144 VPWR VGND sg13g2_decap_8
XFILLER_35_659 VPWR VGND sg13g2_decap_8
XFILLER_34_158 VPWR VGND sg13g2_decap_8
XFILLER_15_361 VPWR VGND sg13g2_decap_8
X_1901_ VPWR VGND _0783_ net108 _0782_ _0243_ _0345_ net60 sg13g2_a221oi_1
X_1832_ VGND VPWR net158 daisychain\[71\] _0732_ net64 sg13g2_a21oi_1
XFILLER_30_375 VPWR VGND sg13g2_fill_2
X_1763_ net199 _0206_ _0679_ _0680_ VPWR VGND sg13g2_a21o_1
X_1694_ net224 VPWR _0628_ VGND state\[38\] net169 sg13g2_o21ai_1
X_2315_ net478 VGND VPWR _0261_ daisychain\[5\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2246_ _0994_ net143 state\[96\] VPWR VGND sg13g2_nand2_1
X_2177_ VGND VPWR _0698_ _0959_ _0445_ net104 sg13g2_a21oi_1
XFILLER_38_475 VPWR VGND sg13g2_decap_8
XFILLER_25_158 VPWR VGND sg13g2_decap_8
XFILLER_31_25 VPWR VGND sg13g2_decap_8
XFILLER_21_386 VPWR VGND sg13g2_fill_2
XFILLER_21_375 VPWR VGND sg13g2_decap_8
Xoutput14 net14 uio_out[6] VPWR VGND sg13g2_buf_1
XFILLER_0_224 VPWR VGND sg13g2_decap_8
XFILLER_49_729 VPWR VGND sg13g2_decap_4
XFILLER_48_217 VPWR VGND sg13g2_decap_8
XFILLER_29_442 VPWR VGND sg13g2_fill_1
X_2453__430 VPWR VGND net429 sg13g2_tiehi
XFILLER_44_467 VPWR VGND sg13g2_decap_4
XFILLER_32_629 VPWR VGND sg13g2_fill_1
XFILLER_16_158 VPWR VGND sg13g2_decap_8
XFILLER_12_375 VPWR VGND sg13g2_decap_8
XFILLER_8_368 VPWR VGND sg13g2_decap_8
XFILLER_4_552 VPWR VGND sg13g2_decap_8
X_2100_ _0921_ net140 state\[23\] VPWR VGND sg13g2_nand2_1
XFILLER_39_217 VPWR VGND sg13g2_decap_8
X_2031_ net164 _0153_ _0880_ _0881_ VPWR VGND sg13g2_a21o_1
XFILLER_47_294 VPWR VGND sg13g2_decap_8
XFILLER_23_607 VPWR VGND sg13g2_decap_8
XFILLER_31_673 VPWR VGND sg13g2_fill_1
XFILLER_30_172 VPWR VGND sg13g2_decap_8
X_1815_ net206 _0220_ _0718_ _0719_ VPWR VGND sg13g2_a21o_1
X_1746_ net225 VPWR _0667_ VGND state\[51\] net193 sg13g2_o21ai_1
X_1677_ VPWR VGND _0615_ net102 _0614_ _0182_ _0289_ net53 sg13g2_a221oi_1
X_2361__387 VPWR VGND net386 sg13g2_tiehi
X_2229_ VGND VPWR _0776_ _0985_ _0471_ net94 sg13g2_a21oi_1
XFILLER_27_924 VPWR VGND sg13g2_fill_2
XFILLER_38_294 VPWR VGND sg13g2_decap_8
XFILLER_26_25 VPWR VGND sg13g2_decap_8
XFILLER_42_35 VPWR VGND sg13g2_decap_8
XFILLER_21_172 VPWR VGND sg13g2_decap_8
XFILLER_5_305 VPWR VGND sg13g2_decap_8
XFILLER_1_511 VPWR VGND sg13g2_decap_8
X_2407__295 VPWR VGND net294 sg13g2_tiehi
XFILLER_3_18 VPWR VGND sg13g2_decap_8
XFILLER_1_588 VPWR VGND sg13g2_decap_8
XFILLER_44_231 VPWR VGND sg13g2_decap_8
XFILLER_32_426 VPWR VGND sg13g2_fill_1
XFILLER_26_990 VPWR VGND sg13g2_decap_8
XFILLER_12_172 VPWR VGND sg13g2_decap_8
XFILLER_9_644 VPWR VGND sg13g2_fill_2
X_1600_ VGND VPWR net122 daisychain\[13\] _0558_ net29 sg13g2_a21oi_1
XFILLER_8_165 VPWR VGND sg13g2_decap_8
X_1531_ VPWR _0244_ daisychain\[8\] VGND sg13g2_inv_1
XFILLER_5_872 VPWR VGND sg13g2_fill_1
X_1462_ VPWR _0230_ daisychain\[77\] VGND sg13g2_inv_1
XFILLER_4_382 VPWR VGND sg13g2_decap_8
X_1393_ VPWR _0037_ state\[18\] VGND sg13g2_inv_1
X_2014_ net223 VPWR _0868_ VGND state\[118\] net181 sg13g2_o21ai_1
XFILLER_48_592 VPWR VGND sg13g2_fill_1
XFILLER_35_231 VPWR VGND sg13g2_decap_8
XFILLER_24_916 VPWR VGND sg13g2_decap_4
XFILLER_23_448 VPWR VGND sg13g2_fill_2
XFILLER_23_415 VPWR VGND sg13g2_fill_1
XFILLER_10_109 VPWR VGND sg13g2_decap_8
X_1729_ VPWR VGND _0654_ net77 _0653_ _0196_ _0302_ net31 sg13g2_a221oi_1
XFILLER_2_319 VPWR VGND sg13g2_decap_8
XFILLER_37_35 VPWR VGND sg13g2_decap_8
XFILLER_42_713 VPWR VGND sg13g2_decap_8
XFILLER_26_242 VPWR VGND sg13g2_decap_8
XFILLER_41_245 VPWR VGND sg13g2_decap_8
XFILLER_5_102 VPWR VGND sg13g2_decap_8
XFILLER_5_179 VPWR VGND sg13g2_decap_8
XFILLER_49_312 VPWR VGND sg13g2_decap_8
XFILLER_1_385 VPWR VGND sg13g2_decap_8
XFILLER_49_389 VPWR VGND sg13g2_decap_8
XFILLER_17_231 VPWR VGND sg13g2_decap_8
XFILLER_32_256 VPWR VGND sg13g2_decap_8
XFILLER_20_418 VPWR VGND sg13g2_fill_2
XFILLER_9_452 VPWR VGND sg13g2_decap_8
XFILLER_13_492 VPWR VGND sg13g2_fill_2
X_2563_ net423 VGND VPWR _0509_ state\[125\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_1514_ VPWR _0173_ daisychain\[25\] VGND sg13g2_inv_1
X_2494_ net265 VGND VPWR _0440_ state\[56\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1445_ VPWR _0249_ daisychain\[94\] VGND sg13g2_inv_1
X_1376_ VPWR _0056_ state\[35\] VGND sg13g2_inv_1
XFILLER_36_573 VPWR VGND sg13g2_decap_4
XFILLER_23_256 VPWR VGND sg13g2_decap_8
XFILLER_2_116 VPWR VGND sg13g2_decap_8
XFILLER_48_56 VPWR VGND sg13g2_decap_8
XFILLER_46_315 VPWR VGND sg13g2_decap_8
XFILLER_27_562 VPWR VGND sg13g2_decap_4
XFILLER_42_510 VPWR VGND sg13g2_fill_2
XFILLER_14_256 VPWR VGND sg13g2_decap_8
XFILLER_9_39 VPWR VGND sg13g2_decap_8
Xfanout60 net62 net60 VPWR VGND sg13g2_buf_1
Xfanout71 net72 net71 VPWR VGND sg13g2_buf_1
Xfanout82 net86 net82 VPWR VGND sg13g2_buf_1
Xfanout93 net94 net93 VPWR VGND sg13g2_buf_1
XFILLER_10_484 VPWR VGND sg13g2_decap_8
XFILLER_6_433 VPWR VGND sg13g2_decap_8
XFILLER_13_81 VPWR VGND sg13g2_decap_8
XFILLER_36_7 VPWR VGND sg13g2_decap_8
XFILLER_2_672 VPWR VGND sg13g2_decap_8
XFILLER_1_182 VPWR VGND sg13g2_decap_8
XFILLER_37_315 VPWR VGND sg13g2_decap_8
XFILLER_49_186 VPWR VGND sg13g2_decap_8
XFILLER_46_882 VPWR VGND sg13g2_fill_1
XFILLER_33_510 VPWR VGND sg13g2_fill_1
XFILLER_45_392 VPWR VGND sg13g2_decap_8
X_1994_ net216 VPWR _0853_ VGND state\[113\] net175 sg13g2_o21ai_1
XFILLER_21_749 VPWR VGND sg13g2_fill_1
XFILLER_0_609 VPWR VGND sg13g2_decap_8
X_2546_ net303 VGND VPWR _0492_ state\[108\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2477_ net333 VGND VPWR _0423_ state\[39\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_1428_ VPWR _0141_ daisychain\[111\] VGND sg13g2_inv_1
XFILLER_29_838 VPWR VGND sg13g2_fill_1
X_1359_ VPWR _0075_ state\[52\] VGND sg13g2_inv_1
XFILLER_28_326 VPWR VGND sg13g2_decap_8
XFILLER_43_329 VPWR VGND sg13g2_decap_8
XFILLER_34_25 VPWR VGND sg13g2_decap_8
XFILLER_8_709 VPWR VGND sg13g2_fill_1
Xclkload2 clkload2/Y clknet_leaf_16_clk VPWR VGND sg13g2_inv_2
XFILLER_3_403 VPWR VGND sg13g2_decap_8
XFILLER_4_959 VPWR VGND sg13g2_decap_4
XFILLER_46_112 VPWR VGND sg13g2_decap_8
XFILLER_19_326 VPWR VGND sg13g2_decap_8
XFILLER_46_189 VPWR VGND sg13g2_decap_8
XFILLER_15_521 VPWR VGND sg13g2_decap_8
XFILLER_15_554 VPWR VGND sg13g2_fill_1
XFILLER_30_579 VPWR VGND sg13g2_decap_8
XFILLER_10_270 VPWR VGND sg13g2_decap_8
X_2400_ net308 VGND VPWR _0346_ daisychain\[90\] clknet_leaf_8_clk sg13g2_dfrbpq_1
XFILLER_6_263 VPWR VGND sg13g2_decap_8
X_2331_ net446 VGND VPWR _0277_ daisychain\[21\] clknet_leaf_1_clk sg13g2_dfrbpq_1
XFILLER_3_981 VPWR VGND sg13g2_fill_2
XFILLER_34_4 VPWR VGND sg13g2_decap_8
X_2262_ _1002_ net135 state\[104\] VPWR VGND sg13g2_nand2_1
X_2193_ VGND VPWR _0722_ _0967_ _0453_ net112 sg13g2_a21oi_1
X_2320__469 VPWR VGND net468 sg13g2_tiehi
XFILLER_37_112 VPWR VGND sg13g2_decap_8
XFILLER_37_189 VPWR VGND sg13g2_decap_8
XFILLER_1_84 VPWR VGND sg13g2_decap_8
XFILLER_33_340 VPWR VGND sg13g2_decap_8
XFILLER_21_546 VPWR VGND sg13g2_fill_1
XFILLER_21_568 VPWR VGND sg13g2_decap_4
X_1977_ VPWR VGND _0840_ net87 _0839_ _0137_ _0364_ net42 sg13g2_a221oi_1
XFILLER_0_406 VPWR VGND sg13g2_decap_8
X_2529_ net275 VGND VPWR _0475_ state\[91\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_29_25 VPWR VGND sg13g2_decap_8
XFILLER_28_123 VPWR VGND sg13g2_decap_8
XFILLER_45_35 VPWR VGND sg13g2_decap_8
XFILLER_44_627 VPWR VGND sg13g2_fill_1
XFILLER_43_126 VPWR VGND sg13g2_decap_8
XFILLER_25_830 VPWR VGND sg13g2_decap_4
X_2371__367 VPWR VGND net366 sg13g2_tiehi
XFILLER_24_340 VPWR VGND sg13g2_decap_8
XFILLER_12_568 VPWR VGND sg13g2_decap_4
XFILLER_6_18 VPWR VGND sg13g2_decap_8
XFILLER_3_200 VPWR VGND sg13g2_decap_8
XFILLER_10_60 VPWR VGND sg13g2_decap_8
XFILLER_3_277 VPWR VGND sg13g2_decap_8
XFILLER_19_123 VPWR VGND sg13g2_decap_8
XFILLER_48_988 VPWR VGND sg13g2_fill_1
X_2417__275 VPWR VGND net274 sg13g2_tiehi
XFILLER_34_137 VPWR VGND sg13g2_decap_8
XFILLER_28_690 VPWR VGND sg13g2_decap_4
XFILLER_15_340 VPWR VGND sg13g2_decap_8
X_1900_ VGND VPWR net155 daisychain\[88\] _0783_ net60 sg13g2_a21oi_1
X_1831_ net207 _0225_ _0730_ _0731_ VPWR VGND sg13g2_a21o_1
XFILLER_30_354 VPWR VGND sg13g2_decap_8
XFILLER_30_365 VPWR VGND sg13g2_fill_2
X_1762_ net227 VPWR _0679_ VGND state\[55\] net199 sg13g2_o21ai_1
X_1693_ VPWR VGND _0627_ net73 _0626_ _0186_ _0293_ net27 sg13g2_a221oi_1
X_2314_ net480 VGND VPWR _0260_ daisychain\[4\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2245_ VGND VPWR _0800_ _0993_ _0479_ net95 sg13g2_a21oi_1
X_2176_ _0959_ net151 state\[61\] VPWR VGND sg13g2_nand2_1
XFILLER_38_498 VPWR VGND sg13g2_decap_8
XFILLER_25_137 VPWR VGND sg13g2_decap_8
XFILLER_34_660 VPWR VGND sg13g2_fill_2
XFILLER_34_693 VPWR VGND sg13g2_decap_4
XFILLER_22_833 VPWR VGND sg13g2_fill_1
X_2546__304 VPWR VGND net303 sg13g2_tiehi
XFILLER_21_354 VPWR VGND sg13g2_decap_8
Xoutput15 net15 uio_out[7] VPWR VGND sg13g2_buf_1
XFILLER_0_203 VPWR VGND sg13g2_decap_8
XFILLER_1_715 VPWR VGND sg13g2_fill_1
XFILLER_5_1022 VPWR VGND sg13g2_decap_8
XFILLER_29_454 VPWR VGND sg13g2_decap_8
XFILLER_16_137 VPWR VGND sg13g2_decap_8
XFILLER_32_608 VPWR VGND sg13g2_fill_1
XFILLER_12_354 VPWR VGND sg13g2_decap_8
XFILLER_40_663 VPWR VGND sg13g2_fill_2
XFILLER_8_347 VPWR VGND sg13g2_decap_8
X_2460__402 VPWR VGND net401 sg13g2_tiehi
X_2527__292 VPWR VGND net291 sg13g2_tiehi
XFILLER_4_531 VPWR VGND sg13g2_decap_8
XFILLER_21_81 VPWR VGND sg13g2_decap_8
X_2030_ net209 VPWR _0880_ VGND state\[122\] net166 sg13g2_o21ai_1
XFILLER_47_273 VPWR VGND sg13g2_decap_8
XFILLER_35_402 VPWR VGND sg13g2_fill_1
XFILLER_35_435 VPWR VGND sg13g2_fill_1
X_2319__471 VPWR VGND net470 sg13g2_tiehi
XFILLER_35_479 VPWR VGND sg13g2_decap_8
XFILLER_16_682 VPWR VGND sg13g2_fill_2
XFILLER_16_671 VPWR VGND sg13g2_decap_8
XFILLER_43_490 VPWR VGND sg13g2_fill_2
XFILLER_31_652 VPWR VGND sg13g2_decap_8
XFILLER_30_151 VPWR VGND sg13g2_decap_8
X_1814_ net231 VPWR _0718_ VGND state\[68\] net206 sg13g2_o21ai_1
X_1745_ VPWR VGND _0666_ net102 _0665_ _0201_ _0306_ net54 sg13g2_a221oi_1
X_1676_ VGND VPWR net149 daisychain\[32\] _0615_ net53 sg13g2_a21oi_1
X_2228_ _0985_ net141 state\[87\] VPWR VGND sg13g2_nand2_1
XFILLER_38_273 VPWR VGND sg13g2_decap_8
X_2159_ VGND VPWR _0671_ _0950_ _0436_ net101 sg13g2_a21oi_1
XFILLER_14_619 VPWR VGND sg13g2_decap_8
XFILLER_42_14 VPWR VGND sg13g2_decap_8
XFILLER_21_151 VPWR VGND sg13g2_decap_8
XFILLER_1_567 VPWR VGND sg13g2_decap_8
XFILLER_45_700 VPWR VGND sg13g2_decap_8
XFILLER_44_210 VPWR VGND sg13g2_decap_8
XFILLER_29_284 VPWR VGND sg13g2_decap_8
XFILLER_44_287 VPWR VGND sg13g2_decap_8
XFILLER_16_81 VPWR VGND sg13g2_decap_8
XFILLER_12_151 VPWR VGND sg13g2_decap_8
XFILLER_9_678 VPWR VGND sg13g2_fill_2
XFILLER_8_144 VPWR VGND sg13g2_decap_8
XFILLER_5_851 VPWR VGND sg13g2_fill_1
X_1530_ VPWR _0255_ daisychain\[9\] VGND sg13g2_inv_1
XFILLER_4_361 VPWR VGND sg13g2_decap_8
X_1461_ VPWR _0231_ daisychain\[78\] VGND sg13g2_inv_1
X_1392_ VPWR _0038_ state\[19\] VGND sg13g2_inv_1
X_2013_ VPWR VGND _0867_ net89 _0866_ _0147_ _0373_ net43 sg13g2_a221oi_1
XFILLER_35_210 VPWR VGND sg13g2_decap_8
XFILLER_35_287 VPWR VGND sg13g2_decap_8
XFILLER_23_427 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_15_clk clknet_2_2__leaf_clk clknet_leaf_15_clk VPWR VGND sg13g2_buf_8
XFILLER_12_39 VPWR VGND sg13g2_decap_8
X_1728_ VGND VPWR net125 daisychain\[45\] _0654_ net31 sg13g2_a21oi_1
X_1659_ net194 _0177_ _0601_ _0602_ VPWR VGND sg13g2_a21o_1
XFILLER_37_14 VPWR VGND sg13g2_decap_8
XFILLER_46_519 VPWR VGND sg13g2_decap_4
XFILLER_39_571 VPWR VGND sg13g2_fill_1
XFILLER_39_593 VPWR VGND sg13g2_fill_2
XFILLER_26_221 VPWR VGND sg13g2_decap_8
XFILLER_41_224 VPWR VGND sg13g2_decap_8
XFILLER_26_298 VPWR VGND sg13g2_decap_8
XFILLER_14_438 VPWR VGND sg13g2_decap_4
XFILLER_23_961 VPWR VGND sg13g2_decap_8
XFILLER_5_158 VPWR VGND sg13g2_decap_8
XFILLER_2_821 VPWR VGND sg13g2_decap_8
XFILLER_2_810 VPWR VGND sg13g2_fill_2
XFILLER_1_364 VPWR VGND sg13g2_decap_8
XFILLER_49_368 VPWR VGND sg13g2_decap_8
XFILLER_18_700 VPWR VGND sg13g2_fill_1
XFILLER_18_722 VPWR VGND sg13g2_fill_1
XFILLER_17_210 VPWR VGND sg13g2_decap_8
XFILLER_45_585 VPWR VGND sg13g2_fill_2
XFILLER_27_91 VPWR VGND sg13g2_decap_8
XFILLER_17_287 VPWR VGND sg13g2_decap_8
XFILLER_32_235 VPWR VGND sg13g2_decap_8
XFILLER_21_909 VPWR VGND sg13g2_fill_2
XFILLER_9_431 VPWR VGND sg13g2_decap_8
X_2562_ net263 VGND VPWR _0508_ state\[124\] clknet_leaf_18_clk sg13g2_dfrbpq_1
X_1513_ VPWR _0174_ daisychain\[26\] VGND sg13g2_inv_1
X_2493_ net269 VGND VPWR _0439_ state\[55\] clknet_leaf_14_clk sg13g2_dfrbpq_1
Xclkbuf_leaf_4_clk clknet_2_1__leaf_clk clknet_leaf_4_clk VPWR VGND sg13g2_buf_8
X_1444_ VPWR _0250_ daisychain\[95\] VGND sg13g2_inv_1
XFILLER_4_95 VPWR VGND sg13g2_decap_8
X_1375_ VPWR _0057_ state\[36\] VGND sg13g2_inv_1
XFILLER_23_235 VPWR VGND sg13g2_decap_8
X_2330__449 VPWR VGND net448 sg13g2_tiehi
XFILLER_3_607 VPWR VGND sg13g2_fill_1
XFILLER_48_35 VPWR VGND sg13g2_decap_8
XFILLER_9_18 VPWR VGND sg13g2_decap_8
XFILLER_42_533 VPWR VGND sg13g2_fill_2
XFILLER_14_235 VPWR VGND sg13g2_decap_8
Xfanout50 net51 net50 VPWR VGND sg13g2_buf_1
Xfanout61 net62 net61 VPWR VGND sg13g2_buf_1
Xfanout72 net81 net72 VPWR VGND sg13g2_buf_1
Xfanout83 net86 net83 VPWR VGND sg13g2_buf_1
Xfanout94 net99 net94 VPWR VGND sg13g2_buf_1
XFILLER_6_401 VPWR VGND sg13g2_decap_8
XFILLER_13_60 VPWR VGND sg13g2_decap_8
XFILLER_10_463 VPWR VGND sg13g2_decap_8
X_2381__347 VPWR VGND net346 sg13g2_tiehi
XFILLER_6_489 VPWR VGND sg13g2_decap_8
XFILLER_1_161 VPWR VGND sg13g2_decap_8
XFILLER_49_165 VPWR VGND sg13g2_decap_8
XFILLER_45_371 VPWR VGND sg13g2_decap_8
X_1993_ VPWR VGND _0852_ net84 _0851_ _0142_ _0368_ net39 sg13g2_a221oi_1
XFILLER_20_249 VPWR VGND sg13g2_decap_8
X_2427__255 VPWR VGND net254 sg13g2_tiehi
X_2545_ net319 VGND VPWR _0491_ state\[107\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2476_ net337 VGND VPWR _0422_ state\[38\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1427_ VPWR _0142_ daisychain\[112\] VGND sg13g2_inv_1
XFILLER_28_305 VPWR VGND sg13g2_decap_8
X_1358_ VPWR _0076_ state\[53\] VGND sg13g2_inv_1
X_1289_ VPWR _0025_ state\[122\] VGND sg13g2_inv_1
XFILLER_43_308 VPWR VGND sg13g2_decap_8
XFILLER_24_511 VPWR VGND sg13g2_decap_8
XFILLER_36_393 VPWR VGND sg13g2_fill_1
XFILLER_36_382 VPWR VGND sg13g2_decap_8
XFILLER_24_544 VPWR VGND sg13g2_decap_8
XFILLER_24_533 VPWR VGND sg13g2_fill_2
XFILLER_24_522 VPWR VGND sg13g2_fill_2
XFILLER_12_717 VPWR VGND sg13g2_decap_4
XFILLER_11_249 VPWR VGND sg13g2_decap_8
Xclkload3 clknet_leaf_17_clk clkload3/Y VPWR VGND sg13g2_inv_4
XFILLER_4_927 VPWR VGND sg13g2_decap_4
XFILLER_3_459 VPWR VGND sg13g2_decap_8
XFILLER_47_614 VPWR VGND sg13g2_decap_8
XFILLER_19_305 VPWR VGND sg13g2_decap_8
XFILLER_46_168 VPWR VGND sg13g2_decap_8
XFILLER_34_319 VPWR VGND sg13g2_decap_8
XFILLER_15_588 VPWR VGND sg13g2_decap_4
XFILLER_24_81 VPWR VGND sg13g2_decap_8
XFILLER_6_242 VPWR VGND sg13g2_decap_8
XFILLER_40_91 VPWR VGND sg13g2_decap_8
X_2330_ net448 VGND VPWR _0276_ daisychain\[20\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2261_ VGND VPWR _0824_ _1001_ _0487_ net95 sg13g2_a21oi_1
XFILLER_2_481 VPWR VGND sg13g2_decap_8
X_2192_ _0967_ net160 state\[69\] VPWR VGND sg13g2_nand2_1
XFILLER_1_63 VPWR VGND sg13g2_decap_8
XFILLER_37_168 VPWR VGND sg13g2_decap_8
XFILLER_25_319 VPWR VGND sg13g2_decap_8
X_1976_ VGND VPWR net134 daisychain\[107\] _0840_ net42 sg13g2_a21oi_1
X_2329__451 VPWR VGND net450 sg13g2_tiehi
XFILLER_20_39 VPWR VGND sg13g2_decap_8
X_2528_ net283 VGND VPWR _0474_ state\[90\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2459_ net405 VGND VPWR _0405_ state\[21\] clknet_leaf_1_clk sg13g2_dfrbpq_1
XFILLER_28_102 VPWR VGND sg13g2_decap_8
XFILLER_29_669 VPWR VGND sg13g2_fill_1
XFILLER_45_14 VPWR VGND sg13g2_decap_8
XFILLER_43_105 VPWR VGND sg13g2_decap_8
XFILLER_28_179 VPWR VGND sg13g2_decap_8
XFILLER_25_820 VPWR VGND sg13g2_decap_8
XFILLER_16_319 VPWR VGND sg13g2_decap_8
XFILLER_24_385 VPWR VGND sg13g2_decap_8
XFILLER_8_529 VPWR VGND sg13g2_decap_8
XFILLER_3_256 VPWR VGND sg13g2_decap_8
XFILLER_19_102 VPWR VGND sg13g2_decap_8
XFILLER_47_455 VPWR VGND sg13g2_decap_8
XFILLER_19_81 VPWR VGND sg13g2_decap_8
XFILLER_47_488 VPWR VGND sg13g2_decap_8
XFILLER_35_617 VPWR VGND sg13g2_decap_4
XFILLER_19_179 VPWR VGND sg13g2_decap_8
XFILLER_34_116 VPWR VGND sg13g2_decap_8
XFILLER_43_683 VPWR VGND sg13g2_decap_8
XFILLER_42_182 VPWR VGND sg13g2_decap_8
XFILLER_35_91 VPWR VGND sg13g2_decap_8
XFILLER_15_396 VPWR VGND sg13g2_decap_8
X_1830_ net231 VPWR _0730_ VGND state\[72\] net207 sg13g2_o21ai_1
XFILLER_30_333 VPWR VGND sg13g2_decap_8
XFILLER_30_377 VPWR VGND sg13g2_fill_1
X_1761_ VPWR VGND _0678_ net105 _0677_ _0205_ _0310_ net56 sg13g2_a221oi_1
X_1692_ VGND VPWR net120 daisychain\[36\] _0627_ net27 sg13g2_a21oi_1
X_2313_ net482 VGND VPWR _0259_ daisychain\[3\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2244_ _0993_ net143 state\[95\] VPWR VGND sg13g2_nand2_1
XFILLER_38_422 VPWR VGND sg13g2_decap_8
X_2175_ VGND VPWR _0695_ _0958_ _0444_ net104 sg13g2_a21oi_1
XFILLER_38_444 VPWR VGND sg13g2_decap_4
XFILLER_26_617 VPWR VGND sg13g2_decap_8
XFILLER_25_116 VPWR VGND sg13g2_decap_8
XFILLER_19_680 VPWR VGND sg13g2_decap_8
XFILLER_15_39 VPWR VGND sg13g2_decap_8
XFILLER_40_119 VPWR VGND sg13g2_decap_8
XFILLER_33_193 VPWR VGND sg13g2_decap_8
XFILLER_21_333 VPWR VGND sg13g2_decap_8
X_1959_ net179 _0133_ _0826_ _0827_ VPWR VGND sg13g2_a21o_1
Xoutput16 net16 uo_out[0] VPWR VGND sg13g2_buf_1
XFILLER_0_259 VPWR VGND sg13g2_decap_8
XFILLER_29_400 VPWR VGND sg13g2_decap_8
XFILLER_16_116 VPWR VGND sg13g2_decap_8
XFILLER_12_333 VPWR VGND sg13g2_decap_8
XFILLER_24_193 VPWR VGND sg13g2_decap_8
XFILLER_8_326 VPWR VGND sg13g2_decap_8
XFILLER_40_675 VPWR VGND sg13g2_decap_8
XFILLER_4_510 VPWR VGND sg13g2_decap_8
XFILLER_21_60 VPWR VGND sg13g2_decap_8
XFILLER_47_252 VPWR VGND sg13g2_decap_8
Xclkbuf_0_clk clknet_0_clk clk VPWR VGND sg13g2_buf_16
XFILLER_31_631 VPWR VGND sg13g2_fill_1
XFILLER_30_130 VPWR VGND sg13g2_decap_8
XFILLER_15_193 VPWR VGND sg13g2_decap_8
X_1813_ VPWR VGND _0717_ net112 _0716_ _0219_ _0323_ net67 sg13g2_a221oi_1
X_1744_ VGND VPWR net154 daisychain\[49\] _0666_ net59 sg13g2_a21oi_1
XFILLER_7_84 VPWR VGND sg13g2_decap_8
XFILLER_7_392 VPWR VGND sg13g2_decap_8
X_1675_ net173 _0182_ _0613_ _0614_ VPWR VGND sg13g2_a21o_1
X_2227_ VGND VPWR _0773_ _0984_ _0470_ net98 sg13g2_a21oi_1
XFILLER_38_252 VPWR VGND sg13g2_decap_8
X_2158_ _0950_ net148 state\[52\] VPWR VGND sg13g2_nand2_1
XFILLER_26_425 VPWR VGND sg13g2_decap_8
X_2089_ VGND VPWR _0566_ _0915_ _0401_ net70 sg13g2_a21oi_1
XFILLER_21_130 VPWR VGND sg13g2_decap_8
XFILLER_22_697 VPWR VGND sg13g2_fill_2
X_2340__429 VPWR VGND net428 sg13g2_tiehi
XFILLER_27_1024 VPWR VGND sg13g2_decap_4
XFILLER_27_1013 VPWR VGND sg13g2_fill_1
XFILLER_1_546 VPWR VGND sg13g2_decap_8
XFILLER_29_263 VPWR VGND sg13g2_decap_8
XFILLER_44_266 VPWR VGND sg13g2_decap_8
XFILLER_26_970 VPWR VGND sg13g2_fill_1
XFILLER_16_60 VPWR VGND sg13g2_decap_8
XFILLER_13_642 VPWR VGND sg13g2_decap_4
XFILLER_12_130 VPWR VGND sg13g2_decap_8
XFILLER_13_675 VPWR VGND sg13g2_decap_4
XFILLER_9_646 VPWR VGND sg13g2_fill_1
XFILLER_8_123 VPWR VGND sg13g2_decap_8
XFILLER_32_81 VPWR VGND sg13g2_decap_8
XFILLER_4_340 VPWR VGND sg13g2_decap_8
X_1460_ VPWR _0232_ daisychain\[79\] VGND sg13g2_inv_1
XFILLER_5_885 VPWR VGND sg13g2_fill_1
X_1391_ VPWR _0040_ state\[20\] VGND sg13g2_inv_1
X_2012_ VGND VPWR net136 daisychain\[116\] _0867_ net43 sg13g2_a21oi_1
X_2391__327 VPWR VGND net326 sg13g2_tiehi
XFILLER_35_266 VPWR VGND sg13g2_decap_8
XFILLER_12_18 VPWR VGND sg13g2_decap_8
X_2845_ daisychain\[127\] net23 VPWR VGND sg13g2_buf_1
X_1727_ net195 _0196_ _0652_ _0653_ VPWR VGND sg13g2_a21o_1
X_1658_ net224 VPWR _0601_ VGND state\[29\] net194 sg13g2_o21ai_1
X_1589_ VPWR VGND _0549_ net70 _0548_ _0150_ _0267_ net24 sg13g2_a221oi_1
XFILLER_27_701 VPWR VGND sg13g2_decap_8
X_2437__235 VPWR VGND net234 sg13g2_tiehi
XFILLER_26_200 VPWR VGND sg13g2_decap_8
XFILLER_41_203 VPWR VGND sg13g2_decap_8
XFILLER_27_789 VPWR VGND sg13g2_decap_8
XFILLER_26_277 VPWR VGND sg13g2_decap_8
XFILLER_14_417 VPWR VGND sg13g2_decap_8
XFILLER_23_951 VPWR VGND sg13g2_fill_1
XFILLER_5_137 VPWR VGND sg13g2_decap_8
XFILLER_1_343 VPWR VGND sg13g2_decap_8
XFILLER_49_347 VPWR VGND sg13g2_decap_8
XFILLER_27_70 VPWR VGND sg13g2_decap_8
XFILLER_45_597 VPWR VGND sg13g2_decap_8
XFILLER_32_214 VPWR VGND sg13g2_decap_8
XFILLER_17_266 VPWR VGND sg13g2_decap_8
XFILLER_9_410 VPWR VGND sg13g2_decap_8
XFILLER_43_91 VPWR VGND sg13g2_decap_8
XFILLER_40_280 VPWR VGND sg13g2_decap_8
XFILLER_13_494 VPWR VGND sg13g2_fill_1
XFILLER_9_487 VPWR VGND sg13g2_decap_8
X_2561_ net327 VGND VPWR _0507_ state\[123\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2492_ net273 VGND VPWR _0438_ state\[54\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1512_ VPWR _0175_ daisychain\[27\] VGND sg13g2_inv_1
XFILLER_5_660 VPWR VGND sg13g2_decap_8
X_1443_ VPWR _0251_ daisychain\[96\] VGND sg13g2_inv_1
XFILLER_4_74 VPWR VGND sg13g2_decap_8
X_1374_ VPWR _0058_ state\[37\] VGND sg13g2_inv_1
XFILLER_48_380 VPWR VGND sg13g2_decap_8
XFILLER_23_214 VPWR VGND sg13g2_decap_8
XFILLER_23_39 VPWR VGND sg13g2_decap_8
XFILLER_31_291 VPWR VGND sg13g2_decap_8
XFILLER_48_14 VPWR VGND sg13g2_decap_8
XFILLER_47_818 VPWR VGND sg13g2_fill_2
X_2339__431 VPWR VGND net430 sg13g2_tiehi
XFILLER_42_556 VPWR VGND sg13g2_fill_1
XFILLER_27_597 VPWR VGND sg13g2_decap_4
XFILLER_14_214 VPWR VGND sg13g2_decap_8
Xfanout40 net42 net40 VPWR VGND sg13g2_buf_1
XFILLER_42_567 VPWR VGND sg13g2_decap_8
Xfanout51 net52 net51 VPWR VGND sg13g2_buf_1
Xfanout62 net63 net62 VPWR VGND sg13g2_buf_1
Xfanout73 net80 net73 VPWR VGND sg13g2_buf_1
XFILLER_10_442 VPWR VGND sg13g2_decap_8
Xfanout84 net86 net84 VPWR VGND sg13g2_buf_1
Xfanout95 net96 net95 VPWR VGND sg13g2_buf_1
XFILLER_22_291 VPWR VGND sg13g2_decap_8
XFILLER_6_468 VPWR VGND sg13g2_decap_8
XFILLER_1_140 VPWR VGND sg13g2_decap_8
XFILLER_49_144 VPWR VGND sg13g2_decap_8
XFILLER_38_91 VPWR VGND sg13g2_decap_8
XFILLER_18_542 VPWR VGND sg13g2_decap_8
XFILLER_45_350 VPWR VGND sg13g2_decap_8
XFILLER_33_578 VPWR VGND sg13g2_decap_8
X_1992_ VGND VPWR net132 daisychain\[111\] _0852_ net39 sg13g2_a21oi_1
XFILLER_20_228 VPWR VGND sg13g2_decap_8
XFILLER_13_291 VPWR VGND sg13g2_decap_8
Xclkload10 clknet_leaf_14_clk clkload10/X VPWR VGND sg13g2_buf_8
XFILLER_9_284 VPWR VGND sg13g2_decap_8
X_2544_ net335 VGND VPWR _0490_ state\[106\] clknet_leaf_4_clk sg13g2_dfrbpq_1
XFILLER_48_0 VPWR VGND sg13g2_decap_8
X_2475_ net341 VGND VPWR _0421_ state\[37\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1426_ VPWR _0143_ daisychain\[113\] VGND sg13g2_inv_1
X_1357_ VPWR _0077_ state\[54\] VGND sg13g2_inv_1
XFILLER_18_39 VPWR VGND sg13g2_decap_8
X_1288_ VPWR _0026_ state\[123\] VGND sg13g2_inv_1
XFILLER_36_350 VPWR VGND sg13g2_decap_8
XFILLER_11_228 VPWR VGND sg13g2_decap_8
Xclkload4 clkload4/Y clknet_leaf_3_clk VPWR VGND sg13g2_inv_2
XFILLER_4_906 VPWR VGND sg13g2_decap_8
XFILLER_3_438 VPWR VGND sg13g2_decap_8
Xfanout230 net232 net230 VPWR VGND sg13g2_buf_1
XFILLER_46_147 VPWR VGND sg13g2_decap_8
XFILLER_27_350 VPWR VGND sg13g2_decap_8
XFILLER_15_534 VPWR VGND sg13g2_decap_8
XFILLER_24_60 VPWR VGND sg13g2_decap_8
XFILLER_30_559 VPWR VGND sg13g2_decap_8
XFILLER_6_221 VPWR VGND sg13g2_decap_8
XFILLER_40_70 VPWR VGND sg13g2_decap_8
XFILLER_6_298 VPWR VGND sg13g2_decap_8
XFILLER_41_7 VPWR VGND sg13g2_decap_8
XFILLER_3_983 VPWR VGND sg13g2_fill_1
X_2260_ _1001_ net135 state\[103\] VPWR VGND sg13g2_nand2_1
XFILLER_2_460 VPWR VGND sg13g2_decap_8
X_2191_ VGND VPWR _0719_ _0966_ _0452_ net113 sg13g2_a21oi_1
XFILLER_38_637 VPWR VGND sg13g2_fill_1
XFILLER_37_147 VPWR VGND sg13g2_decap_8
XFILLER_1_42 VPWR VGND sg13g2_decap_8
XFILLER_18_361 VPWR VGND sg13g2_decap_8
XFILLER_18_372 VPWR VGND sg13g2_fill_2
XFILLER_33_375 VPWR VGND sg13g2_fill_1
X_1975_ net180 _0137_ _0838_ _0839_ VPWR VGND sg13g2_a21o_1
XFILLER_21_559 VPWR VGND sg13g2_fill_1
XFILLER_20_18 VPWR VGND sg13g2_decap_8
X_2527_ net291 VGND VPWR _0473_ state\[89\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2458_ net409 VGND VPWR _0404_ state\[20\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_1409_ VPWR _0050_ state\[2\] VGND sg13g2_inv_1
X_2389_ net330 VGND VPWR _0335_ daisychain\[79\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_44_618 VPWR VGND sg13g2_decap_8
XFILLER_28_158 VPWR VGND sg13g2_decap_8
XFILLER_37_692 VPWR VGND sg13g2_fill_2
XFILLER_8_508 VPWR VGND sg13g2_decap_8
XFILLER_3_235 VPWR VGND sg13g2_decap_8
XFILLER_10_95 VPWR VGND sg13g2_decap_8
XFILLER_0_964 VPWR VGND sg13g2_decap_4
XFILLER_47_434 VPWR VGND sg13g2_decap_8
XFILLER_19_60 VPWR VGND sg13g2_decap_8
XFILLER_19_158 VPWR VGND sg13g2_decap_8
X_2350__409 VPWR VGND net408 sg13g2_tiehi
XFILLER_35_70 VPWR VGND sg13g2_decap_8
XFILLER_42_161 VPWR VGND sg13g2_decap_8
XFILLER_30_312 VPWR VGND sg13g2_decap_8
XFILLER_15_375 VPWR VGND sg13g2_decap_8
X_1760_ VGND VPWR net152 daisychain\[53\] _0678_ net56 sg13g2_a21oi_1
XFILLER_11_581 VPWR VGND sg13g2_decap_8
X_1691_ net169 _0186_ _0625_ _0626_ VPWR VGND sg13g2_a21o_1
X_2312_ net484 VGND VPWR _0258_ daisychain\[2\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2243_ VGND VPWR _0797_ _0992_ _0478_ net98 sg13g2_a21oi_1
X_2174_ _0958_ net151 state\[60\] VPWR VGND sg13g2_nand2_1
XFILLER_15_18 VPWR VGND sg13g2_decap_8
XFILLER_33_172 VPWR VGND sg13g2_decap_8
XFILLER_22_824 VPWR VGND sg13g2_fill_1
XFILLER_21_312 VPWR VGND sg13g2_decap_8
X_1958_ net217 VPWR _0826_ VGND state\[104\] net179 sg13g2_o21ai_1
XFILLER_31_39 VPWR VGND sg13g2_decap_8
X_1889_ VPWR VGND _0774_ net97 _0773_ _0240_ _0342_ net50 sg13g2_a221oi_1
Xoutput17 net17 uo_out[1] VPWR VGND sg13g2_buf_1
XFILLER_0_238 VPWR VGND sg13g2_decap_8
XFILLER_17_607 VPWR VGND sg13g2_fill_2
XFILLER_25_651 VPWR VGND sg13g2_fill_2
XFILLER_12_312 VPWR VGND sg13g2_decap_8
XFILLER_31_109 VPWR VGND sg13g2_decap_8
XFILLER_24_172 VPWR VGND sg13g2_decap_8
XFILLER_8_305 VPWR VGND sg13g2_decap_8
XFILLER_12_389 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[2\].u.inv1 VPWR digitalenL.g\[2\].u.OUTN net6 VGND sg13g2_inv_1
XANTENNA_90 VPWR VGND _0185_ sg13g2_antennanp
XFILLER_4_566 VPWR VGND sg13g2_decap_8
XFILLER_0_750 VPWR VGND sg13g2_decap_8
XFILLER_0_772 VPWR VGND sg13g2_fill_1
XFILLER_47_231 VPWR VGND sg13g2_decap_8
XFILLER_46_91 VPWR VGND sg13g2_decap_8
XFILLER_22_109 VPWR VGND sg13g2_decap_8
XFILLER_15_172 VPWR VGND sg13g2_decap_8
X_1812_ VGND VPWR net160 daisychain\[66\] _0717_ net67 sg13g2_a21oi_1
XFILLER_30_186 VPWR VGND sg13g2_decap_8
X_1743_ net195 _0201_ _0664_ _0665_ VPWR VGND sg13g2_a21o_1
XFILLER_7_63 VPWR VGND sg13g2_decap_8
X_1674_ net212 VPWR _0613_ VGND state\[33\] net173 sg13g2_o21ai_1
XFILLER_7_371 VPWR VGND sg13g2_decap_8
X_2226_ _0984_ net145 state\[86\] VPWR VGND sg13g2_nand2_1
XFILLER_38_231 VPWR VGND sg13g2_decap_8
X_2157_ VGND VPWR _0668_ _0949_ _0435_ net101 sg13g2_a21oi_1
XFILLER_26_39 VPWR VGND sg13g2_decap_8
X_2088_ _0915_ net117 state\[17\] VPWR VGND sg13g2_nand2_1
XFILLER_13_109 VPWR VGND sg13g2_decap_8
XFILLER_34_492 VPWR VGND sg13g2_decap_8
XFILLER_22_643 VPWR VGND sg13g2_fill_2
XFILLER_42_49 VPWR VGND sg13g2_decap_8
XFILLER_22_676 VPWR VGND sg13g2_decap_4
XFILLER_21_186 VPWR VGND sg13g2_decap_8
XFILLER_5_319 VPWR VGND sg13g2_decap_8
XFILLER_1_525 VPWR VGND sg13g2_decap_8
XFILLER_29_242 VPWR VGND sg13g2_decap_8
XFILLER_45_724 VPWR VGND sg13g2_decap_4
XFILLER_17_437 VPWR VGND sg13g2_decap_8
XFILLER_44_245 VPWR VGND sg13g2_decap_8
XFILLER_25_492 VPWR VGND sg13g2_fill_2
XFILLER_9_614 VPWR VGND sg13g2_fill_2
XFILLER_8_102 VPWR VGND sg13g2_decap_8
XFILLER_12_186 VPWR VGND sg13g2_decap_8
X_2349__411 VPWR VGND net410 sg13g2_tiehi
XFILLER_40_484 VPWR VGND sg13g2_fill_2
XFILLER_8_179 VPWR VGND sg13g2_decap_8
XFILLER_32_60 VPWR VGND sg13g2_decap_8
XFILLER_5_842 VPWR VGND sg13g2_fill_2
XFILLER_5_864 VPWR VGND sg13g2_fill_1
XFILLER_5_897 VPWR VGND sg13g2_fill_2
X_1390_ VPWR _0041_ state\[21\] VGND sg13g2_inv_1
XFILLER_4_396 VPWR VGND sg13g2_decap_8
X_2011_ net181 _0147_ _0865_ _0866_ VPWR VGND sg13g2_a21o_1
XFILLER_35_245 VPWR VGND sg13g2_decap_8
X_2844_ daisychain\[126\] net22 VPWR VGND sg13g2_buf_1
X_1726_ net226 VPWR _0652_ VGND state\[46\] net195 sg13g2_o21ai_1
X_1657_ VPWR VGND _0600_ net73 _0599_ _0176_ _0284_ net27 sg13g2_a221oi_1
X_1588_ VGND VPWR net117 daisychain\[10\] _0549_ net24 sg13g2_a21oi_1
XFILLER_37_49 VPWR VGND sg13g2_decap_8
X_2209_ VGND VPWR _0746_ _0975_ _0461_ net112 sg13g2_a21oi_1
XFILLER_2_1027 VPWR VGND sg13g2_fill_2
XFILLER_2_1016 VPWR VGND sg13g2_decap_8
XFILLER_26_256 VPWR VGND sg13g2_decap_8
XFILLER_41_259 VPWR VGND sg13g2_decap_8
XFILLER_5_116 VPWR VGND sg13g2_decap_8
XFILLER_1_322 VPWR VGND sg13g2_decap_8
XFILLER_2_878 VPWR VGND sg13g2_fill_1
XFILLER_49_326 VPWR VGND sg13g2_decap_8
XFILLER_1_399 VPWR VGND sg13g2_decap_8
XFILLER_17_245 VPWR VGND sg13g2_decap_8
Xclkbuf_2_0__f_clk clknet_2_0__leaf_clk clknet_0_clk VPWR VGND sg13g2_buf_16
XFILLER_45_565 VPWR VGND sg13g2_fill_1
XFILLER_43_70 VPWR VGND sg13g2_decap_8
XFILLER_9_466 VPWR VGND sg13g2_decap_8
X_2560_ net391 VGND VPWR _0506_ state\[122\] clknet_leaf_18_clk sg13g2_dfrbpq_1
X_2491_ net277 VGND VPWR _0437_ state\[53\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1511_ VPWR _0176_ daisychain\[28\] VGND sg13g2_inv_1
X_1442_ VPWR _0252_ daisychain\[97\] VGND sg13g2_inv_1
XFILLER_4_193 VPWR VGND sg13g2_decap_8
XFILLER_4_53 VPWR VGND sg13g2_decap_8
X_1373_ VPWR _0059_ state\[38\] VGND sg13g2_inv_1
XFILLER_49_871 VPWR VGND sg13g2_fill_2
XFILLER_24_716 VPWR VGND sg13g2_fill_1
XFILLER_23_18 VPWR VGND sg13g2_decap_8
XFILLER_31_270 VPWR VGND sg13g2_decap_8
X_1709_ VPWR VGND _0639_ net107 _0638_ _0191_ _0297_ net59 sg13g2_a221oi_1
XFILLER_24_1017 VPWR VGND sg13g2_decap_8
XFILLER_24_1006 VPWR VGND sg13g2_fill_1
XFILLER_24_1028 VPWR VGND sg13g2_fill_1
XFILLER_46_329 VPWR VGND sg13g2_decap_8
XFILLER_27_543 VPWR VGND sg13g2_decap_8
Xfanout30 net33 net30 VPWR VGND sg13g2_buf_1
Xfanout41 net42 net41 VPWR VGND sg13g2_buf_1
Xfanout52 net69 net52 VPWR VGND sg13g2_buf_1
Xfanout63 net69 net63 VPWR VGND sg13g2_buf_1
Xfanout74 net80 net74 VPWR VGND sg13g2_buf_1
XFILLER_22_270 VPWR VGND sg13g2_decap_8
XFILLER_10_421 VPWR VGND sg13g2_decap_8
Xfanout85 net86 net85 VPWR VGND sg13g2_buf_1
Xfanout96 net98 net96 VPWR VGND sg13g2_buf_1
XFILLER_10_498 VPWR VGND sg13g2_decap_8
XFILLER_6_447 VPWR VGND sg13g2_decap_8
XFILLER_13_95 VPWR VGND sg13g2_decap_8
XFILLER_2_642 VPWR VGND sg13g2_decap_8
XFILLER_49_123 VPWR VGND sg13g2_decap_8
XFILLER_2_697 VPWR VGND sg13g2_fill_2
XFILLER_2_686 VPWR VGND sg13g2_decap_8
XFILLER_1_196 VPWR VGND sg13g2_decap_8
XFILLER_38_70 VPWR VGND sg13g2_decap_8
XFILLER_37_329 VPWR VGND sg13g2_decap_8
XFILLER_46_852 VPWR VGND sg13g2_decap_8
XFILLER_18_587 VPWR VGND sg13g2_decap_8
XFILLER_13_270 VPWR VGND sg13g2_decap_8
X_1991_ net178 _0142_ _0850_ _0851_ VPWR VGND sg13g2_a21o_1
XFILLER_20_207 VPWR VGND sg13g2_decap_8
XFILLER_9_263 VPWR VGND sg13g2_decap_8
Xclkload11 clkload11/Y clknet_leaf_15_clk VPWR VGND sg13g2_inv_2
X_2543_ net351 VGND VPWR _0489_ state\[105\] clknet_leaf_2_clk sg13g2_dfrbpq_1
XFILLER_47_1028 VPWR VGND sg13g2_fill_1
XFILLER_47_1017 VPWR VGND sg13g2_decap_8
X_2474_ net345 VGND VPWR _0420_ state\[36\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1425_ VPWR _0144_ daisychain\[114\] VGND sg13g2_inv_1
X_1356_ VPWR _0078_ state\[55\] VGND sg13g2_inv_1
XFILLER_18_18 VPWR VGND sg13g2_decap_8
X_1287_ VPWR _0027_ state\[124\] VGND sg13g2_inv_1
XFILLER_34_39 VPWR VGND sg13g2_decap_8
XFILLER_11_207 VPWR VGND sg13g2_decap_8
Xclkload5 clkload5/Y clknet_leaf_4_clk VPWR VGND sg13g2_inv_2
XFILLER_3_417 VPWR VGND sg13g2_decap_8
XFILLER_1_7 VPWR VGND sg13g2_decap_8
Xfanout231 net232 net231 VPWR VGND sg13g2_buf_1
Xfanout220 net222 net220 VPWR VGND sg13g2_buf_1
XFILLER_46_126 VPWR VGND sg13g2_decap_8
XFILLER_27_395 VPWR VGND sg13g2_decap_8
XFILLER_42_343 VPWR VGND sg13g2_decap_8
XFILLER_6_200 VPWR VGND sg13g2_decap_8
XFILLER_10_284 VPWR VGND sg13g2_decap_8
XFILLER_6_277 VPWR VGND sg13g2_decap_8
X_2504__476 VPWR VGND net475 sg13g2_tiehi
X_2190_ _0966_ net161 state\[68\] VPWR VGND sg13g2_nand2_1
XFILLER_1_21 VPWR VGND sg13g2_decap_8
XFILLER_38_649 VPWR VGND sg13g2_decap_4
XFILLER_37_126 VPWR VGND sg13g2_decap_8
XFILLER_1_98 VPWR VGND sg13g2_decap_8
XFILLER_18_340 VPWR VGND sg13g2_decap_8
X_2357__395 VPWR VGND net394 sg13g2_tiehi
XFILLER_33_354 VPWR VGND sg13g2_decap_8
X_1974_ net217 VPWR _0838_ VGND state\[108\] net180 sg13g2_o21ai_1
X_2526_ net299 VGND VPWR _0472_ state\[88\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2457_ net413 VGND VPWR _0403_ state\[19\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_1408_ VPWR _0061_ state\[3\] VGND sg13g2_inv_1
XFILLER_29_39 VPWR VGND sg13g2_decap_8
X_2388_ net332 VGND VPWR _0334_ daisychain\[78\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_29_616 VPWR VGND sg13g2_fill_2
X_1339_ VPWR _0097_ state\[72\] VGND sg13g2_inv_1
XFILLER_28_137 VPWR VGND sg13g2_decap_8
XFILLER_37_660 VPWR VGND sg13g2_fill_2
XFILLER_45_49 VPWR VGND sg13g2_decap_8
XFILLER_37_671 VPWR VGND sg13g2_fill_2
XFILLER_24_354 VPWR VGND sg13g2_decap_8
XFILLER_12_505 VPWR VGND sg13g2_decap_8
XFILLER_12_527 VPWR VGND sg13g2_decap_8
XFILLER_4_715 VPWR VGND sg13g2_decap_8
XFILLER_3_214 VPWR VGND sg13g2_decap_8
XFILLER_0_910 VPWR VGND sg13g2_decap_8
XFILLER_10_74 VPWR VGND sg13g2_decap_8
XFILLER_47_413 VPWR VGND sg13g2_decap_8
XFILLER_19_137 VPWR VGND sg13g2_decap_8
XFILLER_35_608 VPWR VGND sg13g2_fill_2
XFILLER_43_641 VPWR VGND sg13g2_decap_8
XFILLER_15_354 VPWR VGND sg13g2_decap_8
XFILLER_42_140 VPWR VGND sg13g2_decap_8
X_1690_ net214 VPWR _0625_ VGND state\[37\] net169 sg13g2_o21ai_1
X_2311_ net486 VGND VPWR _0257_ daisychain\[1\] clknet_leaf_2_clk sg13g2_dfrbpq_1
XFILLER_3_792 VPWR VGND sg13g2_decap_8
XFILLER_32_4 VPWR VGND sg13g2_decap_8
XFILLER_2_291 VPWR VGND sg13g2_decap_8
X_2242_ _0992_ net145 state\[94\] VPWR VGND sg13g2_nand2_1
X_2173_ VGND VPWR _0692_ _0957_ _0443_ net104 sg13g2_a21oi_1
XFILLER_38_457 VPWR VGND sg13g2_fill_2
XFILLER_19_693 VPWR VGND sg13g2_decap_4
XFILLER_33_151 VPWR VGND sg13g2_decap_8
XFILLER_22_803 VPWR VGND sg13g2_fill_2
XFILLER_21_368 VPWR VGND sg13g2_decap_8
X_1957_ VPWR VGND _0825_ net95 _0824_ _0132_ _0359_ net51 sg13g2_a221oi_1
XFILLER_31_18 VPWR VGND sg13g2_decap_8
X_1888_ VGND VPWR net144 daisychain\[85\] _0774_ net50 sg13g2_a21oi_1
Xoutput18 net18 uo_out[2] VPWR VGND sg13g2_buf_1
XFILLER_0_217 VPWR VGND sg13g2_decap_8
X_2509_ net435 VGND VPWR _0455_ state\[71\] clknet_leaf_11_clk sg13g2_dfrbpq_1
XFILLER_25_641 VPWR VGND sg13g2_decap_4
XFILLER_25_685 VPWR VGND sg13g2_fill_2
XFILLER_24_151 VPWR VGND sg13g2_decap_8
XFILLER_12_368 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[2\].u.inv2 VPWR digitalenL.g\[2\].u.OUTP digitalenL.g\[2\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_21_880 VPWR VGND sg13g2_fill_1
XANTENNA_80 VPWR VGND state\[104\] sg13g2_antennanp
XANTENNA_91 VPWR VGND _0187_ sg13g2_antennanp
X_2486__298 VPWR VGND net297 sg13g2_tiehi
XFILLER_4_545 VPWR VGND sg13g2_decap_8
XFILLER_21_95 VPWR VGND sg13g2_decap_8
XFILLER_47_210 VPWR VGND sg13g2_decap_8
XFILLER_47_287 VPWR VGND sg13g2_decap_8
XFILLER_46_70 VPWR VGND sg13g2_decap_8
XFILLER_15_151 VPWR VGND sg13g2_decap_8
X_1811_ net206 _0219_ _0715_ _0716_ VPWR VGND sg13g2_a21o_1
XFILLER_31_666 VPWR VGND sg13g2_decap_8
XFILLER_30_165 VPWR VGND sg13g2_decap_8
X_1742_ net226 VPWR _0664_ VGND state\[50\] net195 sg13g2_o21ai_1
XFILLER_7_42 VPWR VGND sg13g2_decap_8
XFILLER_7_350 VPWR VGND sg13g2_decap_8
X_1673_ VPWR VGND _0612_ net101 _0611_ _0181_ _0288_ net55 sg13g2_a221oi_1
X_2225_ VGND VPWR _0770_ _0983_ _0469_ net97 sg13g2_a21oi_1
XFILLER_38_210 VPWR VGND sg13g2_decap_8
X_2156_ _0949_ net148 state\[51\] VPWR VGND sg13g2_nand2_1
XFILLER_38_287 VPWR VGND sg13g2_decap_8
XFILLER_26_18 VPWR VGND sg13g2_decap_8
X_2087_ VGND VPWR _0563_ _0914_ _0400_ net75 sg13g2_a21oi_1
Xclkbuf_leaf_18_clk clknet_2_0__leaf_clk clknet_leaf_18_clk VPWR VGND sg13g2_buf_8
XFILLER_34_460 VPWR VGND sg13g2_decap_8
XFILLER_42_28 VPWR VGND sg13g2_decap_8
XFILLER_21_165 VPWR VGND sg13g2_decap_8
XFILLER_1_504 VPWR VGND sg13g2_decap_8
XFILLER_29_221 VPWR VGND sg13g2_decap_8
XFILLER_17_427 VPWR VGND sg13g2_fill_2
XFILLER_44_224 VPWR VGND sg13g2_decap_8
XFILLER_29_298 VPWR VGND sg13g2_decap_8
XFILLER_26_983 VPWR VGND sg13g2_fill_1
XFILLER_16_95 VPWR VGND sg13g2_decap_8
XFILLER_12_165 VPWR VGND sg13g2_decap_8
XFILLER_8_158 VPWR VGND sg13g2_decap_8
XFILLER_5_876 VPWR VGND sg13g2_fill_1
XFILLER_4_375 VPWR VGND sg13g2_decap_8
XFILLER_0_581 VPWR VGND sg13g2_decap_8
X_2010_ net223 VPWR _0865_ VGND state\[117\] net181 sg13g2_o21ai_1
XFILLER_35_224 VPWR VGND sg13g2_decap_8
X_2843_ daisychain\[125\] net21 VPWR VGND sg13g2_buf_1
X_1725_ VPWR VGND _0651_ net77 _0650_ _0195_ _0301_ net31 sg13g2_a221oi_1
X_1656_ VGND VPWR net121 daisychain\[27\] _0600_ net28 sg13g2_a21oi_1
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk clknet_leaf_7_clk VPWR VGND sg13g2_buf_8
X_1587_ net167 _0150_ _0547_ _0548_ VPWR VGND sg13g2_a21o_1
XFILLER_37_28 VPWR VGND sg13g2_decap_8
X_2208_ _0975_ net160 state\[77\] VPWR VGND sg13g2_nand2_1
XFILLER_39_585 VPWR VGND sg13g2_fill_1
X_2139_ VGND VPWR _0641_ _0940_ _0426_ net78 sg13g2_a21oi_1
XFILLER_26_235 VPWR VGND sg13g2_decap_8
XFILLER_42_706 VPWR VGND sg13g2_decap_8
XFILLER_41_238 VPWR VGND sg13g2_decap_8
XFILLER_23_975 VPWR VGND sg13g2_decap_4
XFILLER_22_485 VPWR VGND sg13g2_fill_1
XFILLER_1_301 VPWR VGND sg13g2_decap_8
XFILLER_49_305 VPWR VGND sg13g2_decap_8
XFILLER_1_378 VPWR VGND sg13g2_decap_8
XFILLER_45_555 VPWR VGND sg13g2_fill_2
XFILLER_17_224 VPWR VGND sg13g2_decap_8
X_2316__477 VPWR VGND net476 sg13g2_tiehi
XFILLER_32_249 VPWR VGND sg13g2_decap_8
XFILLER_13_452 VPWR VGND sg13g2_fill_2
XFILLER_9_445 VPWR VGND sg13g2_decap_8
X_2507__452 VPWR VGND net451 sg13g2_tiehi
X_2490_ net281 VGND VPWR _0436_ state\[52\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1510_ VPWR _0177_ daisychain\[29\] VGND sg13g2_inv_1
X_1441_ VPWR _0253_ daisychain\[98\] VGND sg13g2_inv_1
XFILLER_4_32 VPWR VGND sg13g2_decap_8
XFILLER_4_172 VPWR VGND sg13g2_decap_8
X_1372_ VPWR _0060_ state\[39\] VGND sg13g2_inv_1
XFILLER_36_500 VPWR VGND sg13g2_decap_8
XFILLER_36_566 VPWR VGND sg13g2_decap_8
XFILLER_23_249 VPWR VGND sg13g2_decap_8
X_2367__375 VPWR VGND net374 sg13g2_tiehi
X_1708_ VGND VPWR net154 daisychain\[40\] _0639_ net59 sg13g2_a21oi_1
XFILLER_2_109 VPWR VGND sg13g2_decap_8
X_1639_ net185 _0172_ _0586_ _0587_ VPWR VGND sg13g2_a21o_1
XFILLER_48_49 VPWR VGND sg13g2_decap_8
X_2519__356 VPWR VGND net355 sg13g2_tiehi
XFILLER_46_308 VPWR VGND sg13g2_decap_8
XFILLER_27_511 VPWR VGND sg13g2_decap_8
Xfanout31 net33 net31 VPWR VGND sg13g2_buf_1
XFILLER_14_249 VPWR VGND sg13g2_decap_8
XFILLER_10_400 VPWR VGND sg13g2_decap_8
Xfanout42 net52 net42 VPWR VGND sg13g2_buf_1
Xfanout53 net58 net53 VPWR VGND sg13g2_buf_1
Xfanout64 net68 net64 VPWR VGND sg13g2_buf_1
XFILLER_23_794 VPWR VGND sg13g2_decap_4
Xfanout75 net80 net75 VPWR VGND sg13g2_buf_1
Xfanout86 net90 net86 VPWR VGND sg13g2_buf_1
Xfanout97 net98 net97 VPWR VGND sg13g2_buf_1
XFILLER_10_477 VPWR VGND sg13g2_decap_8
XFILLER_6_426 VPWR VGND sg13g2_decap_8
XFILLER_13_74 VPWR VGND sg13g2_decap_8
XFILLER_2_621 VPWR VGND sg13g2_decap_8
XFILLER_49_102 VPWR VGND sg13g2_decap_8
XFILLER_1_175 VPWR VGND sg13g2_decap_8
XFILLER_49_179 VPWR VGND sg13g2_decap_8
XFILLER_37_308 VPWR VGND sg13g2_decap_8
XFILLER_46_831 VPWR VGND sg13g2_fill_2
XFILLER_18_522 VPWR VGND sg13g2_decap_8
XFILLER_45_385 VPWR VGND sg13g2_decap_8
X_1990_ net216 VPWR _0850_ VGND state\[112\] net178 sg13g2_o21ai_1
XFILLER_21_709 VPWR VGND sg13g2_decap_4
XFILLER_9_242 VPWR VGND sg13g2_decap_8
XFILLER_41_580 VPWR VGND sg13g2_fill_2
Xclkload12 clknet_leaf_8_clk clkload12/X VPWR VGND sg13g2_buf_8
X_2542_ net367 VGND VPWR _0488_ state\[104\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2473_ net349 VGND VPWR _0419_ state\[35\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_1424_ VPWR _0145_ daisychain\[115\] VGND sg13g2_inv_1
X_1355_ VPWR _0079_ state\[56\] VGND sg13g2_inv_1
XFILLER_28_319 VPWR VGND sg13g2_decap_8
X_1286_ VPWR _0028_ state\[125\] VGND sg13g2_inv_1
XFILLER_24_503 VPWR VGND sg13g2_fill_2
XFILLER_34_18 VPWR VGND sg13g2_decap_8
Xclkload6 clkload6/Y clknet_leaf_6_clk VPWR VGND sg13g2_inv_2
Xfanout232 net233 net232 VPWR VGND sg13g2_buf_1
Xfanout221 net222 net221 VPWR VGND sg13g2_buf_1
Xfanout210 net233 net210 VPWR VGND sg13g2_buf_1
XFILLER_46_105 VPWR VGND sg13g2_decap_8
XFILLER_19_319 VPWR VGND sg13g2_decap_8
XFILLER_15_514 VPWR VGND sg13g2_decap_8
XFILLER_42_322 VPWR VGND sg13g2_decap_8
XFILLER_23_580 VPWR VGND sg13g2_decap_8
XFILLER_24_95 VPWR VGND sg13g2_decap_8
XFILLER_10_263 VPWR VGND sg13g2_decap_8
XFILLER_6_256 VPWR VGND sg13g2_decap_8
XFILLER_3_996 VPWR VGND sg13g2_fill_1
XFILLER_49_81 VPWR VGND sg13g2_decap_8
XFILLER_2_495 VPWR VGND sg13g2_decap_8
XFILLER_27_7 VPWR VGND sg13g2_decap_8
XFILLER_37_105 VPWR VGND sg13g2_decap_8
XFILLER_1_77 VPWR VGND sg13g2_decap_8
XFILLER_18_385 VPWR VGND sg13g2_fill_2
XFILLER_45_182 VPWR VGND sg13g2_decap_8
XFILLER_33_333 VPWR VGND sg13g2_decap_8
X_1973_ VPWR VGND _0837_ net87 _0836_ _0136_ _0363_ net40 sg13g2_a221oi_1
XFILLER_21_539 VPWR VGND sg13g2_decap_8
X_2525_ net307 VGND VPWR _0471_ state\[87\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2456_ net417 VGND VPWR _0402_ state\[18\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_1407_ VPWR _0072_ state\[4\] VGND sg13g2_inv_1
XFILLER_29_18 VPWR VGND sg13g2_decap_8
X_2387_ net334 VGND VPWR _0333_ daisychain\[77\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_29_606 VPWR VGND sg13g2_fill_1
X_1338_ VPWR _0098_ state\[73\] VGND sg13g2_inv_1
XFILLER_28_116 VPWR VGND sg13g2_decap_8
XFILLER_45_28 VPWR VGND sg13g2_decap_8
XFILLER_44_609 VPWR VGND sg13g2_decap_4
XFILLER_37_650 VPWR VGND sg13g2_fill_2
XFILLER_43_119 VPWR VGND sg13g2_decap_8
XFILLER_37_694 VPWR VGND sg13g2_fill_1
XFILLER_36_182 VPWR VGND sg13g2_decap_8
XFILLER_24_333 VPWR VGND sg13g2_decap_8
XFILLER_10_53 VPWR VGND sg13g2_decap_8
XFILLER_0_900 VPWR VGND sg13g2_fill_1
XFILLER_0_933 VPWR VGND sg13g2_decap_4
XFILLER_0_977 VPWR VGND sg13g2_decap_4
XFILLER_48_937 VPWR VGND sg13g2_fill_2
XFILLER_19_116 VPWR VGND sg13g2_decap_8
XFILLER_47_469 VPWR VGND sg13g2_fill_2
XFILLER_28_661 VPWR VGND sg13g2_decap_4
XFILLER_19_95 VPWR VGND sg13g2_decap_8
XFILLER_28_683 VPWR VGND sg13g2_decap_8
XFILLER_27_182 VPWR VGND sg13g2_decap_8
XFILLER_15_333 VPWR VGND sg13g2_decap_8
XFILLER_42_196 VPWR VGND sg13g2_decap_8
XFILLER_30_347 VPWR VGND sg13g2_decap_8
XFILLER_7_521 VPWR VGND sg13g2_decap_8
X_2310_ net487 VGND VPWR _0256_ daisychain\[0\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2241_ VGND VPWR _0794_ _0991_ _0477_ net107 sg13g2_a21oi_1
XFILLER_2_270 VPWR VGND sg13g2_decap_8
XFILLER_25_4 VPWR VGND sg13g2_decap_8
X_2172_ _0957_ net151 state\[59\] VPWR VGND sg13g2_nand2_1
XFILLER_19_661 VPWR VGND sg13g2_fill_2
XFILLER_18_193 VPWR VGND sg13g2_decap_8
XFILLER_33_130 VPWR VGND sg13g2_decap_8
X_1956_ VGND VPWR net143 daisychain\[102\] _0825_ net51 sg13g2_a21oi_1
XFILLER_21_347 VPWR VGND sg13g2_decap_8
X_1887_ net190 _0240_ _0772_ _0773_ VPWR VGND sg13g2_a21o_1
Xoutput19 net19 uo_out[3] VPWR VGND sg13g2_buf_1
X_2508_ net443 VGND VPWR _0454_ state\[70\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_2439_ net485 VGND VPWR _0385_ state\[1\] clknet_leaf_3_clk sg13g2_dfrbpq_1
XFILLER_17_609 VPWR VGND sg13g2_fill_1
XFILLER_44_406 VPWR VGND sg13g2_decap_8
XFILLER_24_130 VPWR VGND sg13g2_decap_8
XFILLER_12_347 VPWR VGND sg13g2_decap_8
XFILLER_21_892 VPWR VGND sg13g2_fill_1
XANTENNA_70 VPWR VGND daisychain\[38\] sg13g2_antennanp
XANTENNA_81 VPWR VGND state\[104\] sg13g2_antennanp
XANTENNA_92 VPWR VGND _0187_ sg13g2_antennanp
XFILLER_4_524 VPWR VGND sg13g2_decap_8
XFILLER_21_74 VPWR VGND sg13g2_decap_8
XFILLER_47_266 VPWR VGND sg13g2_decap_8
XFILLER_44_951 VPWR VGND sg13g2_fill_2
XFILLER_16_653 VPWR VGND sg13g2_decap_8
XFILLER_15_130 VPWR VGND sg13g2_decap_8
XFILLER_43_483 VPWR VGND sg13g2_decap_8
X_1810_ net231 VPWR _0715_ VGND state\[67\] net206 sg13g2_o21ai_1
XFILLER_30_144 VPWR VGND sg13g2_decap_8
XFILLER_7_21 VPWR VGND sg13g2_decap_8
X_1741_ VPWR VGND _0663_ net102 _0662_ _0199_ _0305_ net53 sg13g2_a221oi_1
X_1672_ VGND VPWR net148 daisychain\[31\] _0612_ net55 sg13g2_a21oi_1
XFILLER_7_98 VPWR VGND sg13g2_decap_8
X_2326__457 VPWR VGND net456 sg13g2_tiehi
X_2224_ _0983_ net145 state\[85\] VPWR VGND sg13g2_nand2_1
X_2155_ VGND VPWR _0665_ _0948_ _0434_ net103 sg13g2_a21oi_1
XFILLER_27_907 VPWR VGND sg13g2_fill_2
XFILLER_38_266 VPWR VGND sg13g2_decap_8
X_2086_ _0914_ net122 state\[16\] VPWR VGND sg13g2_nand2_1
XFILLER_26_439 VPWR VGND sg13g2_fill_2
XFILLER_41_409 VPWR VGND sg13g2_decap_8
XFILLER_21_144 VPWR VGND sg13g2_decap_8
X_1939_ net184 _0254_ _0811_ _0812_ VPWR VGND sg13g2_a21o_1
XFILLER_29_200 VPWR VGND sg13g2_decap_8
X_2377__355 VPWR VGND net354 sg13g2_tiehi
XFILLER_44_203 VPWR VGND sg13g2_decap_8
XFILLER_29_277 VPWR VGND sg13g2_decap_8
XFILLER_16_74 VPWR VGND sg13g2_decap_8
XFILLER_12_144 VPWR VGND sg13g2_decap_8
XFILLER_9_616 VPWR VGND sg13g2_fill_1
XFILLER_40_453 VPWR VGND sg13g2_decap_4
XFILLER_8_137 VPWR VGND sg13g2_decap_8
XFILLER_32_95 VPWR VGND sg13g2_decap_8
XFILLER_5_855 VPWR VGND sg13g2_fill_2
XFILLER_4_354 VPWR VGND sg13g2_decap_8
XFILLER_0_560 VPWR VGND sg13g2_decap_8
XFILLER_35_203 VPWR VGND sg13g2_decap_8
XFILLER_43_280 VPWR VGND sg13g2_decap_8
XFILLER_31_442 VPWR VGND sg13g2_fill_2
X_2842_ daisychain\[124\] net20 VPWR VGND sg13g2_buf_1
X_1724_ VGND VPWR net125 daisychain\[44\] _0651_ net31 sg13g2_a21oi_1
XFILLER_8_671 VPWR VGND sg13g2_decap_4
X_1655_ net169 _0176_ _0598_ _0599_ VPWR VGND sg13g2_a21o_1
X_1586_ net210 VPWR _0547_ VGND state\[11\] net167 sg13g2_o21ai_1
X_2207_ VGND VPWR _0743_ _0974_ _0460_ net109 sg13g2_a21oi_1
XFILLER_27_715 VPWR VGND sg13g2_fill_2
X_2138_ _0940_ net126 state\[42\] VPWR VGND sg13g2_nand2_1
XFILLER_27_748 VPWR VGND sg13g2_fill_2
XFILLER_26_214 VPWR VGND sg13g2_decap_8
X_2069_ VGND VPWR _0536_ _0905_ _0391_ net71 sg13g2_a21oi_1
XFILLER_41_217 VPWR VGND sg13g2_decap_8
XFILLER_34_291 VPWR VGND sg13g2_decap_8
XFILLER_22_442 VPWR VGND sg13g2_decap_4
XFILLER_10_648 VPWR VGND sg13g2_fill_2
XFILLER_10_659 VPWR VGND sg13g2_decap_4
XFILLER_2_803 VPWR VGND sg13g2_fill_2
XFILLER_2_858 VPWR VGND sg13g2_decap_4
XFILLER_1_357 VPWR VGND sg13g2_decap_8
XFILLER_18_715 VPWR VGND sg13g2_decap_8
XFILLER_17_203 VPWR VGND sg13g2_decap_8
XFILLER_45_534 VPWR VGND sg13g2_decap_4
XFILLER_45_578 VPWR VGND sg13g2_fill_2
XFILLER_27_84 VPWR VGND sg13g2_decap_8
XFILLER_32_228 VPWR VGND sg13g2_decap_8
XFILLER_26_770 VPWR VGND sg13g2_decap_8
XFILLER_25_291 VPWR VGND sg13g2_decap_8
XFILLER_13_431 VPWR VGND sg13g2_decap_8
XFILLER_9_424 VPWR VGND sg13g2_decap_8
XFILLER_40_294 VPWR VGND sg13g2_decap_8
XFILLER_5_674 VPWR VGND sg13g2_fill_2
XFILLER_4_151 VPWR VGND sg13g2_decap_8
X_1440_ VPWR _0254_ daisychain\[99\] VGND sg13g2_inv_1
XFILLER_4_11 VPWR VGND sg13g2_decap_8
X_1371_ VPWR _0062_ state\[40\] VGND sg13g2_inv_1
XFILLER_4_88 VPWR VGND sg13g2_decap_8
XFILLER_48_361 VPWR VGND sg13g2_fill_2
XFILLER_48_350 VPWR VGND sg13g2_decap_8
XFILLER_36_512 VPWR VGND sg13g2_decap_8
XFILLER_48_394 VPWR VGND sg13g2_decap_8
XFILLER_23_228 VPWR VGND sg13g2_decap_8
XFILLER_16_291 VPWR VGND sg13g2_decap_8
X_2547__288 VPWR VGND net287 sg13g2_tiehi
X_1707_ net201 _0191_ _0637_ _0638_ VPWR VGND sg13g2_a21o_1
X_1638_ net218 VPWR _0586_ VGND state\[24\] net185 sg13g2_o21ai_1
X_1569_ VPWR VGND _0534_ net91 _0533_ _0222_ _0262_ net44 sg13g2_a221oi_1
XFILLER_48_28 VPWR VGND sg13g2_decap_8
XFILLER_39_350 VPWR VGND sg13g2_decap_8
XFILLER_14_228 VPWR VGND sg13g2_decap_8
XFILLER_42_548 VPWR VGND sg13g2_fill_2
Xfanout43 net52 net43 VPWR VGND sg13g2_buf_1
Xfanout54 net58 net54 VPWR VGND sg13g2_buf_1
Xfanout65 net68 net65 VPWR VGND sg13g2_buf_1
Xfanout32 net33 net32 VPWR VGND sg13g2_buf_1
XFILLER_23_762 VPWR VGND sg13g2_decap_8
Xfanout76 net79 net76 VPWR VGND sg13g2_buf_1
Xfanout87 net90 net87 VPWR VGND sg13g2_buf_1
Xfanout98 net99 net98 VPWR VGND sg13g2_buf_1
XFILLER_10_456 VPWR VGND sg13g2_decap_8
XFILLER_13_53 VPWR VGND sg13g2_decap_8
XFILLER_2_600 VPWR VGND sg13g2_decap_8
XFILLER_1_154 VPWR VGND sg13g2_decap_8
XFILLER_49_158 VPWR VGND sg13g2_decap_8
XFILLER_45_364 VPWR VGND sg13g2_decap_8
XFILLER_9_221 VPWR VGND sg13g2_decap_8
Xclkload13 clknet_leaf_10_clk clkload13/Y VPWR VGND sg13g2_inv_4
XFILLER_9_298 VPWR VGND sg13g2_decap_8
X_2541_ net383 VGND VPWR _0487_ state\[103\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2472_ net353 VGND VPWR _0418_ state\[34\] clknet_leaf_16_clk sg13g2_dfrbpq_1
XFILLER_5_482 VPWR VGND sg13g2_decap_8
X_1423_ VPWR _0146_ daisychain\[116\] VGND sg13g2_inv_1
X_1354_ VPWR _0080_ state\[57\] VGND sg13g2_inv_1
X_1285_ VPWR _0029_ state\[126\] VGND sg13g2_inv_1
XFILLER_36_364 VPWR VGND sg13g2_fill_2
Xclkload7 VPWR clkload7/Y clknet_leaf_7_clk VGND sg13g2_inv_1
Xfanout222 net223 net222 VPWR VGND sg13g2_buf_1
Xfanout211 net214 net211 VPWR VGND sg13g2_buf_1
Xfanout200 net5 net200 VPWR VGND sg13g2_buf_1
Xfanout233 net4 net233 VPWR VGND sg13g2_buf_1
XFILLER_28_821 VPWR VGND sg13g2_fill_1
XFILLER_42_301 VPWR VGND sg13g2_decap_8
XFILLER_27_364 VPWR VGND sg13g2_decap_8
X_2489__286 VPWR VGND net285 sg13g2_tiehi
XFILLER_24_74 VPWR VGND sg13g2_decap_8
XFILLER_10_242 VPWR VGND sg13g2_decap_8
XFILLER_6_235 VPWR VGND sg13g2_decap_8
XFILLER_40_84 VPWR VGND sg13g2_decap_8
XFILLER_3_975 VPWR VGND sg13g2_fill_1
XFILLER_2_474 VPWR VGND sg13g2_decap_8
XFILLER_49_60 VPWR VGND sg13g2_decap_8
XFILLER_1_56 VPWR VGND sg13g2_decap_8
XFILLER_46_695 VPWR VGND sg13g2_decap_8
XFILLER_45_161 VPWR VGND sg13g2_decap_8
XFILLER_33_312 VPWR VGND sg13g2_decap_8
XFILLER_21_518 VPWR VGND sg13g2_fill_2
X_1972_ VGND VPWR net134 daisychain\[106\] _0837_ net40 sg13g2_a21oi_1
XdigitalenH.g\[0\].u.inv1 VPWR digitalenH.g\[0\].u.OUTN net7 VGND sg13g2_inv_1
X_2524_ net315 VGND VPWR _0470_ state\[86\] clknet_leaf_6_clk sg13g2_dfrbpq_1
XFILLER_46_0 VPWR VGND sg13g2_decap_8
X_2455_ net421 VGND VPWR _0401_ state\[17\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2386_ net336 VGND VPWR _0332_ daisychain\[76\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_1406_ VPWR _0083_ state\[5\] VGND sg13g2_inv_1
X_1337_ VPWR _0099_ state\[74\] VGND sg13g2_inv_1
XFILLER_29_618 VPWR VGND sg13g2_fill_1
X_2336__437 VPWR VGND net436 sg13g2_tiehi
XFILLER_37_662 VPWR VGND sg13g2_fill_1
XFILLER_36_161 VPWR VGND sg13g2_decap_8
XFILLER_25_813 VPWR VGND sg13g2_fill_2
XFILLER_25_857 VPWR VGND sg13g2_decap_8
XFILLER_24_312 VPWR VGND sg13g2_decap_8
XFILLER_24_378 VPWR VGND sg13g2_decap_8
XFILLER_20_562 VPWR VGND sg13g2_decap_8
XFILLER_10_32 VPWR VGND sg13g2_decap_8
XFILLER_3_249 VPWR VGND sg13g2_decap_8
XFILLER_19_74 VPWR VGND sg13g2_decap_8
XFILLER_47_448 VPWR VGND sg13g2_decap_8
XFILLER_34_109 VPWR VGND sg13g2_decap_8
XFILLER_27_161 VPWR VGND sg13g2_decap_8
XFILLER_15_312 VPWR VGND sg13g2_decap_8
XFILLER_35_84 VPWR VGND sg13g2_decap_8
XFILLER_42_175 VPWR VGND sg13g2_decap_8
XFILLER_30_326 VPWR VGND sg13g2_decap_8
XFILLER_15_389 VPWR VGND sg13g2_decap_8
X_2387__335 VPWR VGND net334 sg13g2_tiehi
XFILLER_7_500 VPWR VGND sg13g2_decap_8
XFILLER_11_573 VPWR VGND sg13g2_fill_2
XFILLER_11_595 VPWR VGND sg13g2_fill_2
XFILLER_3_750 VPWR VGND sg13g2_decap_8
X_2240_ _0991_ net154 state\[93\] VPWR VGND sg13g2_nand2_1
X_2171_ VGND VPWR _0689_ _0956_ _0442_ net104 sg13g2_a21oi_1
XFILLER_18_4 VPWR VGND sg13g2_decap_8
XFILLER_38_459 VPWR VGND sg13g2_fill_1
XFILLER_25_109 VPWR VGND sg13g2_decap_8
XFILLER_19_673 VPWR VGND sg13g2_decap_8
X_2550__240 VPWR VGND net239 sg13g2_tiehi
XFILLER_18_172 VPWR VGND sg13g2_decap_8
XFILLER_33_186 VPWR VGND sg13g2_decap_8
XFILLER_21_326 VPWR VGND sg13g2_decap_8
X_1955_ net188 _0132_ _0823_ _0824_ VPWR VGND sg13g2_a21o_1
X_1886_ net221 VPWR _0772_ VGND state\[86\] net189 sg13g2_o21ai_1
X_2507_ net451 VGND VPWR _0453_ state\[69\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2438_ net488 VGND VPWR _0384_ state\[0\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2369_ net370 VGND VPWR _0315_ daisychain\[59\] clknet_leaf_11_clk sg13g2_dfrbpq_1
XFILLER_45_919 VPWR VGND sg13g2_fill_1
XFILLER_29_448 VPWR VGND sg13g2_fill_1
XFILLER_16_109 VPWR VGND sg13g2_decap_8
XFILLER_12_326 VPWR VGND sg13g2_decap_8
XFILLER_24_186 VPWR VGND sg13g2_decap_8
XFILLER_8_319 VPWR VGND sg13g2_decap_8
XFILLER_40_668 VPWR VGND sg13g2_decap_8
XFILLER_21_871 VPWR VGND sg13g2_fill_1
XANTENNA_60 VPWR VGND daisychain\[20\] sg13g2_antennanp
XANTENNA_71 VPWR VGND daisychain\[40\] sg13g2_antennanp
XANTENNA_82 VPWR VGND state\[116\] sg13g2_antennanp
XANTENNA_93 VPWR VGND _0193_ sg13g2_antennanp
XFILLER_4_503 VPWR VGND sg13g2_decap_8
XFILLER_21_53 VPWR VGND sg13g2_decap_8
XFILLER_0_720 VPWR VGND sg13g2_fill_1
XFILLER_0_764 VPWR VGND sg13g2_fill_2
XFILLER_47_245 VPWR VGND sg13g2_decap_8
XFILLER_35_418 VPWR VGND sg13g2_decap_4
XFILLER_29_993 VPWR VGND sg13g2_fill_2
XFILLER_43_462 VPWR VGND sg13g2_fill_1
XFILLER_15_186 VPWR VGND sg13g2_decap_8
XFILLER_30_123 VPWR VGND sg13g2_decap_8
X_1740_ VGND VPWR net149 daisychain\[48\] _0663_ net53 sg13g2_a21oi_1
X_2545__320 VPWR VGND net319 sg13g2_tiehi
X_1671_ net193 _0181_ _0610_ _0611_ VPWR VGND sg13g2_a21o_1
XFILLER_7_77 VPWR VGND sg13g2_decap_8
XFILLER_7_385 VPWR VGND sg13g2_decap_8
X_2223_ VGND VPWR _0767_ _0982_ _0468_ net97 sg13g2_a21oi_1
X_2154_ _0948_ net150 state\[50\] VPWR VGND sg13g2_nand2_1
XFILLER_38_245 VPWR VGND sg13g2_decap_8
X_2085_ VGND VPWR _0560_ _0913_ _0399_ net75 sg13g2_a21oi_1
XFILLER_34_440 VPWR VGND sg13g2_fill_1
XFILLER_21_123 VPWR VGND sg13g2_decap_8
X_1938_ net219 VPWR _0811_ VGND state\[99\] net184 sg13g2_o21ai_1
X_1869_ VPWR VGND _0759_ net93 _0758_ _0235_ _0337_ net45 sg13g2_a221oi_1
XFILLER_27_1028 VPWR VGND sg13g2_fill_1
XFILLER_27_1017 VPWR VGND sg13g2_decap_8
XFILLER_1_539 VPWR VGND sg13g2_decap_8
XFILLER_29_256 VPWR VGND sg13g2_decap_8
XFILLER_17_407 VPWR VGND sg13g2_decap_4
XFILLER_44_259 VPWR VGND sg13g2_decap_8
XFILLER_16_53 VPWR VGND sg13g2_decap_8
XFILLER_13_635 VPWR VGND sg13g2_decap_8
XFILLER_12_123 VPWR VGND sg13g2_decap_8
XFILLER_13_668 VPWR VGND sg13g2_decap_8
XFILLER_13_646 VPWR VGND sg13g2_fill_2
XFILLER_8_116 VPWR VGND sg13g2_decap_8
XFILLER_32_74 VPWR VGND sg13g2_decap_8
XFILLER_4_333 VPWR VGND sg13g2_decap_8
XFILLER_5_889 VPWR VGND sg13g2_fill_1
XFILLER_35_259 VPWR VGND sg13g2_decap_8
X_2841_ daisychain\[123\] net19 VPWR VGND sg13g2_buf_1
XFILLER_31_498 VPWR VGND sg13g2_decap_4
X_1723_ net173 _0195_ _0649_ _0650_ VPWR VGND sg13g2_a21o_1
XFILLER_7_182 VPWR VGND sg13g2_decap_8
X_1654_ net211 VPWR _0598_ VGND state\[28\] net169 sg13g2_o21ai_1
X_1585_ VPWR VGND _0546_ net70 _0545_ _0139_ _0266_ net24 sg13g2_a221oi_1
X_2206_ _0974_ net156 state\[76\] VPWR VGND sg13g2_nand2_1
X_2137_ VGND VPWR _0638_ _0939_ _0425_ net102 sg13g2_a21oi_1
X_2068_ _0905_ net118 state\[7\] VPWR VGND sg13g2_nand2_1
XFILLER_34_270 VPWR VGND sg13g2_decap_8
XFILLER_10_616 VPWR VGND sg13g2_fill_2
X_2413__283 VPWR VGND net282 sg13g2_tiehi
XFILLER_6_609 VPWR VGND sg13g2_fill_1
XFILLER_1_336 VPWR VGND sg13g2_decap_8
XFILLER_27_63 VPWR VGND sg13g2_decap_8
XFILLER_17_259 VPWR VGND sg13g2_decap_8
XFILLER_32_207 VPWR VGND sg13g2_decap_8
XFILLER_13_410 VPWR VGND sg13g2_decap_8
XFILLER_25_270 VPWR VGND sg13g2_decap_8
XFILLER_9_403 VPWR VGND sg13g2_decap_8
XFILLER_43_84 VPWR VGND sg13g2_decap_8
XFILLER_40_273 VPWR VGND sg13g2_decap_8
XFILLER_5_653 VPWR VGND sg13g2_decap_8
XFILLER_4_130 VPWR VGND sg13g2_decap_8
X_1370_ VPWR _0063_ state\[41\] VGND sg13g2_inv_1
XFILLER_4_67 VPWR VGND sg13g2_decap_8
XFILLER_49_830 VPWR VGND sg13g2_decap_8
XFILLER_49_885 VPWR VGND sg13g2_fill_1
XFILLER_48_373 VPWR VGND sg13g2_decap_8
XFILLER_36_535 VPWR VGND sg13g2_decap_8
XFILLER_23_207 VPWR VGND sg13g2_decap_8
XFILLER_16_270 VPWR VGND sg13g2_decap_8
XFILLER_31_284 VPWR VGND sg13g2_decap_8
XFILLER_8_480 VPWR VGND sg13g2_decap_8
X_1706_ net226 VPWR _0637_ VGND state\[41\] net195 sg13g2_o21ai_1
X_1637_ VPWR VGND _0585_ net93 _0584_ _0171_ _0279_ net45 sg13g2_a221oi_1
X_1568_ VGND VPWR net138 daisychain\[5\] _0534_ net44 sg13g2_a21oi_1
X_1499_ VPWR _0190_ daisychain\[40\] VGND sg13g2_inv_1
XFILLER_27_557 VPWR VGND sg13g2_fill_1
XFILLER_14_207 VPWR VGND sg13g2_decap_8
Xfanout44 net46 net44 VPWR VGND sg13g2_buf_1
Xfanout55 net58 net55 VPWR VGND sg13g2_buf_1
Xfanout33 net34 net33 VPWR VGND sg13g2_buf_1
XFILLER_10_435 VPWR VGND sg13g2_decap_8
XFILLER_13_32 VPWR VGND sg13g2_decap_8
Xfanout66 net68 net66 VPWR VGND sg13g2_buf_1
Xfanout77 net79 net77 VPWR VGND sg13g2_buf_1
Xfanout88 net90 net88 VPWR VGND sg13g2_buf_1
Xfanout99 net115 net99 VPWR VGND sg13g2_buf_1
XFILLER_22_284 VPWR VGND sg13g2_decap_8
X_2346__417 VPWR VGND net416 sg13g2_tiehi
X_2461__398 VPWR VGND net397 sg13g2_tiehi
XFILLER_2_656 VPWR VGND sg13g2_decap_4
XFILLER_1_133 VPWR VGND sg13g2_decap_8
XFILLER_49_137 VPWR VGND sg13g2_decap_8
XFILLER_46_833 VPWR VGND sg13g2_fill_1
XFILLER_38_84 VPWR VGND sg13g2_decap_8
XFILLER_46_866 VPWR VGND sg13g2_decap_8
XFILLER_45_343 VPWR VGND sg13g2_decap_8
XFILLER_9_200 VPWR VGND sg13g2_decap_8
XFILLER_13_284 VPWR VGND sg13g2_decap_8
XFILLER_41_593 VPWR VGND sg13g2_fill_1
XFILLER_9_277 VPWR VGND sg13g2_decap_8
Xclkload14 clkload14/Y clknet_leaf_11_clk VPWR VGND sg13g2_inv_2
X_2540_ net399 VGND VPWR _0486_ state\[102\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2471_ net357 VGND VPWR _0417_ state\[33\] clknet_leaf_15_clk sg13g2_dfrbpq_1
XFILLER_5_461 VPWR VGND sg13g2_decap_8
X_1422_ VPWR _0147_ daisychain\[117\] VGND sg13g2_inv_1
X_2397__315 VPWR VGND net314 sg13g2_tiehi
X_1353_ VPWR _0081_ state\[58\] VGND sg13g2_inv_1
X_1284_ VPWR _1026_ net210 VGND sg13g2_inv_1
XFILLER_49_693 VPWR VGND sg13g2_fill_1
XFILLER_36_343 VPWR VGND sg13g2_decap_8
XFILLER_36_376 VPWR VGND sg13g2_fill_1
XFILLER_24_505 VPWR VGND sg13g2_fill_1
XFILLER_32_571 VPWR VGND sg13g2_fill_1
Xclkload8 VPWR clkload8/Y clknet_leaf_12_clk VGND sg13g2_inv_1
Xfanout223 net233 net223 VPWR VGND sg13g2_buf_1
Xfanout212 net214 net212 VPWR VGND sg13g2_buf_1
Xfanout201 net208 net201 VPWR VGND sg13g2_buf_1
XFILLER_27_343 VPWR VGND sg13g2_decap_8
XFILLER_42_357 VPWR VGND sg13g2_decap_4
XFILLER_11_711 VPWR VGND sg13g2_decap_8
XFILLER_11_722 VPWR VGND sg13g2_fill_1
XFILLER_24_53 VPWR VGND sg13g2_decap_8
XFILLER_10_221 VPWR VGND sg13g2_decap_8
XFILLER_6_214 VPWR VGND sg13g2_decap_8
XFILLER_10_298 VPWR VGND sg13g2_decap_8
XFILLER_40_63 VPWR VGND sg13g2_decap_8
XFILLER_2_453 VPWR VGND sg13g2_decap_8
X_2496__258 VPWR VGND net257 sg13g2_tiehi
XFILLER_1_35 VPWR VGND sg13g2_decap_8
XFILLER_46_630 VPWR VGND sg13g2_fill_2
XFILLER_46_663 VPWR VGND sg13g2_fill_1
XFILLER_45_140 VPWR VGND sg13g2_decap_8
XFILLER_18_354 VPWR VGND sg13g2_decap_8
XFILLER_33_368 VPWR VGND sg13g2_decap_8
X_1971_ net179 _0136_ _0835_ _0836_ VPWR VGND sg13g2_a21o_1
X_2523_ net323 VGND VPWR _0469_ state\[85\] clknet_leaf_6_clk sg13g2_dfrbpq_1
XdigitalenH.g\[0\].u.inv2 VPWR digitalenH.g\[0\].u.OUTP digitalenH.g\[0\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_5_291 VPWR VGND sg13g2_decap_8
X_2454_ net425 VGND VPWR _0400_ state\[16\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2385_ net338 VGND VPWR _0331_ daisychain\[75\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_1405_ VPWR _0094_ state\[6\] VGND sg13g2_inv_1
XFILLER_39_0 VPWR VGND sg13g2_decap_8
X_1336_ VPWR _0100_ state\[75\] VGND sg13g2_inv_1
Xinput1 rst_n net1 VPWR VGND sg13g2_buf_1
X_2555__344 VPWR VGND net343 sg13g2_tiehi
XFILLER_49_490 VPWR VGND sg13g2_decap_8
XFILLER_37_685 VPWR VGND sg13g2_decap_8
XFILLER_36_140 VPWR VGND sg13g2_decap_8
XFILLER_12_519 VPWR VGND sg13g2_fill_1
XFILLER_24_368 VPWR VGND sg13g2_decap_4
XFILLER_10_11 VPWR VGND sg13g2_decap_8
XFILLER_3_228 VPWR VGND sg13g2_decap_8
XFILLER_10_88 VPWR VGND sg13g2_decap_8
XFILLER_47_427 VPWR VGND sg13g2_decap_8
XFILLER_19_53 VPWR VGND sg13g2_decap_8
XFILLER_28_630 VPWR VGND sg13g2_decap_8
XFILLER_27_140 VPWR VGND sg13g2_decap_8
XFILLER_43_655 VPWR VGND sg13g2_fill_1
XFILLER_42_154 VPWR VGND sg13g2_decap_8
XFILLER_35_63 VPWR VGND sg13g2_decap_8
XFILLER_15_368 VPWR VGND sg13g2_decap_8
XFILLER_30_305 VPWR VGND sg13g2_decap_8
XFILLER_11_563 VPWR VGND sg13g2_fill_1
X_2170_ _0956_ net151 state\[58\] VPWR VGND sg13g2_nand2_1
XFILLER_19_663 VPWR VGND sg13g2_fill_1
XFILLER_18_151 VPWR VGND sg13g2_decap_8
XFILLER_46_493 VPWR VGND sg13g2_decap_8
XFILLER_34_622 VPWR VGND sg13g2_decap_8
XFILLER_33_165 VPWR VGND sg13g2_decap_8
XFILLER_21_305 VPWR VGND sg13g2_decap_8
X_1954_ net220 VPWR _0823_ VGND state\[103\] net180 sg13g2_o21ai_1
X_1885_ VPWR VGND _0771_ net97 _0770_ _0239_ _0341_ net50 sg13g2_a221oi_1
X_2506_ net459 VGND VPWR _0452_ state\[68\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_2522__332 VPWR VGND net331 sg13g2_tiehi
X_2437_ net234 VGND VPWR _0383_ daisychain\[127\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2368_ net372 VGND VPWR _0314_ daisychain\[58\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_2299_ VGND VPWR _0881_ _1020_ _0506_ net70 sg13g2_a21oi_1
X_1319_ VPWR _0119_ state\[92\] VGND sg13g2_inv_1
XFILLER_25_622 VPWR VGND sg13g2_decap_8
XFILLER_12_305 VPWR VGND sg13g2_decap_8
XFILLER_40_625 VPWR VGND sg13g2_fill_2
XFILLER_24_165 VPWR VGND sg13g2_decap_8
XFILLER_21_850 VPWR VGND sg13g2_fill_1
XANTENNA_50 VPWR VGND _0224_ sg13g2_antennanp
XANTENNA_61 VPWR VGND daisychain\[20\] sg13g2_antennanp
XANTENNA_72 VPWR VGND daisychain\[42\] sg13g2_antennanp
XANTENNA_83 VPWR VGND state\[116\] sg13g2_antennanp
XFILLER_20_382 VPWR VGND sg13g2_decap_8
XANTENNA_94 VPWR VGND _0193_ sg13g2_antennanp
XFILLER_21_32 VPWR VGND sg13g2_decap_8
XFILLER_4_559 VPWR VGND sg13g2_decap_8
X_2423__263 VPWR VGND net262 sg13g2_tiehi
XFILLER_0_743 VPWR VGND sg13g2_decap_8
XFILLER_47_224 VPWR VGND sg13g2_decap_8
X_2534__236 VPWR VGND net235 sg13g2_tiehi
XFILLER_29_983 VPWR VGND sg13g2_fill_2
XFILLER_46_84 VPWR VGND sg13g2_decap_8
XFILLER_16_633 VPWR VGND sg13g2_fill_2
XFILLER_43_452 VPWR VGND sg13g2_fill_2
XFILLER_43_474 VPWR VGND sg13g2_decap_4
XFILLER_31_636 VPWR VGND sg13g2_fill_2
XFILLER_30_102 VPWR VGND sg13g2_decap_8
XFILLER_15_165 VPWR VGND sg13g2_decap_8
XFILLER_30_179 VPWR VGND sg13g2_decap_8
XFILLER_11_382 VPWR VGND sg13g2_decap_8
X_1670_ net225 VPWR _0610_ VGND state\[32\] net193 sg13g2_o21ai_1
XFILLER_7_56 VPWR VGND sg13g2_decap_8
XFILLER_7_364 VPWR VGND sg13g2_decap_8
XFILLER_3_592 VPWR VGND sg13g2_fill_2
XFILLER_30_4 VPWR VGND sg13g2_decap_8
X_2222_ _0982_ net144 state\[84\] VPWR VGND sg13g2_nand2_1
X_2153_ VGND VPWR _0662_ _0947_ _0433_ net100 sg13g2_a21oi_1
XFILLER_38_224 VPWR VGND sg13g2_decap_8
X_2084_ _0913_ net122 state\[15\] VPWR VGND sg13g2_nand2_1
XFILLER_34_452 VPWR VGND sg13g2_fill_2
XFILLER_34_474 VPWR VGND sg13g2_fill_1
XFILLER_21_102 VPWR VGND sg13g2_decap_8
XFILLER_21_179 VPWR VGND sg13g2_decap_8
X_1937_ VPWR VGND _0810_ net96 _0809_ _0253_ _0354_ net47 sg13g2_a221oi_1
X_1868_ VGND VPWR net144 daisychain\[80\] _0759_ net49 sg13g2_a21oi_1
X_1799_ net207 _0216_ _0706_ _0707_ VPWR VGND sg13g2_a21o_1
XFILLER_1_518 VPWR VGND sg13g2_decap_8
XFILLER_29_235 VPWR VGND sg13g2_decap_8
XFILLER_45_728 VPWR VGND sg13g2_fill_1
XFILLER_44_238 VPWR VGND sg13g2_decap_8
XFILLER_16_32 VPWR VGND sg13g2_decap_8
XFILLER_12_102 VPWR VGND sg13g2_decap_8
XFILLER_26_997 VPWR VGND sg13g2_fill_1
XFILLER_40_477 VPWR VGND sg13g2_decap_8
XFILLER_12_179 VPWR VGND sg13g2_decap_8
XFILLER_32_53 VPWR VGND sg13g2_decap_8
XFILLER_5_802 VPWR VGND sg13g2_fill_1
XFILLER_4_312 VPWR VGND sg13g2_decap_8
XFILLER_5_868 VPWR VGND sg13g2_fill_1
XFILLER_4_389 VPWR VGND sg13g2_decap_8
XFILLER_0_595 VPWR VGND sg13g2_decap_8
XFILLER_48_588 VPWR VGND sg13g2_decap_4
XFILLER_48_555 VPWR VGND sg13g2_decap_4
XFILLER_35_238 VPWR VGND sg13g2_decap_8
XFILLER_44_750 VPWR VGND sg13g2_fill_1
XFILLER_44_794 VPWR VGND sg13g2_decap_8
XFILLER_44_761 VPWR VGND sg13g2_decap_4
XFILLER_16_463 VPWR VGND sg13g2_fill_1
X_2840_ daisychain\[122\] net18 VPWR VGND sg13g2_buf_1
XFILLER_31_466 VPWR VGND sg13g2_decap_4
X_1722_ net213 VPWR _0649_ VGND state\[45\] net173 sg13g2_o21ai_1
X_1653_ VPWR VGND _0597_ net73 _0596_ _0175_ _0283_ net28 sg13g2_a221oi_1
XFILLER_7_161 VPWR VGND sg13g2_decap_8
X_1584_ VGND VPWR net117 daisychain\[9\] _0546_ net24 sg13g2_a21oi_1
X_2205_ VGND VPWR _0740_ _0973_ _0459_ net110 sg13g2_a21oi_1
X_2136_ _0939_ net149 state\[41\] VPWR VGND sg13g2_nand2_1
X_2067_ VGND VPWR _0533_ _0904_ _0390_ net91 sg13g2_a21oi_1
XFILLER_26_249 VPWR VGND sg13g2_decap_8
XFILLER_23_934 VPWR VGND sg13g2_decap_4
XFILLER_5_109 VPWR VGND sg13g2_decap_8
XFILLER_1_315 VPWR VGND sg13g2_decap_8
XFILLER_49_319 VPWR VGND sg13g2_decap_8
XFILLER_27_42 VPWR VGND sg13g2_decap_8
XFILLER_17_238 VPWR VGND sg13g2_decap_8
XFILLER_43_63 VPWR VGND sg13g2_decap_8
XFILLER_40_252 VPWR VGND sg13g2_decap_8
XFILLER_9_459 VPWR VGND sg13g2_decap_8
XFILLER_5_610 VPWR VGND sg13g2_decap_8
X_2542__368 VPWR VGND net367 sg13g2_tiehi
XFILLER_4_46 VPWR VGND sg13g2_decap_8
XFILLER_4_186 VPWR VGND sg13g2_decap_8
XFILLER_0_392 VPWR VGND sg13g2_decap_8
XFILLER_31_263 VPWR VGND sg13g2_decap_8
X_1705_ VPWR VGND _0636_ net77 _0635_ _0190_ _0296_ net32 sg13g2_a221oi_1
X_1636_ VGND VPWR net140 daisychain\[22\] _0585_ net45 sg13g2_a21oi_1
X_1567_ net183 _0222_ _0532_ _0533_ VPWR VGND sg13g2_a21o_1
X_1498_ VPWR _0191_ daisychain\[41\] VGND sg13g2_inv_1
XFILLER_27_525 VPWR VGND sg13g2_decap_4
X_2119_ VGND VPWR _0611_ _0930_ _0416_ net101 sg13g2_a21oi_1
XFILLER_23_742 VPWR VGND sg13g2_decap_8
Xfanout45 net46 net45 VPWR VGND sg13g2_buf_1
Xfanout56 net58 net56 VPWR VGND sg13g2_buf_1
Xfanout34 net35 net34 VPWR VGND sg13g2_buf_1
XFILLER_10_414 VPWR VGND sg13g2_decap_8
XFILLER_13_11 VPWR VGND sg13g2_decap_8
Xfanout67 net68 net67 VPWR VGND sg13g2_buf_1
Xfanout78 net79 net78 VPWR VGND sg13g2_buf_1
Xfanout89 net90 net89 VPWR VGND sg13g2_buf_1
XFILLER_22_263 VPWR VGND sg13g2_decap_8
XFILLER_13_88 VPWR VGND sg13g2_decap_8
XFILLER_8_4 VPWR VGND sg13g2_decap_8
XFILLER_2_635 VPWR VGND sg13g2_decap_8
XFILLER_1_112 VPWR VGND sg13g2_decap_8
XFILLER_2_679 VPWR VGND sg13g2_decap_8
XFILLER_49_116 VPWR VGND sg13g2_decap_8
XFILLER_1_189 VPWR VGND sg13g2_decap_8
XFILLER_38_63 VPWR VGND sg13g2_decap_8
X_2537__448 VPWR VGND net447 sg13g2_tiehi
XFILLER_46_845 VPWR VGND sg13g2_fill_2
XFILLER_45_322 VPWR VGND sg13g2_decap_8
XFILLER_33_506 VPWR VGND sg13g2_decap_4
XFILLER_45_399 VPWR VGND sg13g2_decap_8
XFILLER_13_263 VPWR VGND sg13g2_decap_8
XFILLER_9_256 VPWR VGND sg13g2_decap_8
X_2470_ net361 VGND VPWR _0416_ state\[32\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1421_ VPWR _0148_ daisychain\[118\] VGND sg13g2_inv_1
X_1352_ VPWR _0082_ state\[59\] VGND sg13g2_inv_1
X_1283_ VPWR _0030_ state\[127\] VGND sg13g2_inv_1
XFILLER_49_672 VPWR VGND sg13g2_decap_8
XFILLER_48_182 VPWR VGND sg13g2_decap_8
XFILLER_36_322 VPWR VGND sg13g2_decap_8
XFILLER_36_366 VPWR VGND sg13g2_fill_1
Xclkload9 clknet_leaf_13_clk clkload9/Y VPWR VGND sg13g2_inv_4
X_1619_ net172 _0166_ _0571_ _0572_ VPWR VGND sg13g2_a21o_1
Xfanout213 net214 net213 VPWR VGND sg13g2_buf_1
Xfanout202 net208 net202 VPWR VGND sg13g2_buf_1
Xfanout224 net226 net224 VPWR VGND sg13g2_buf_1
XFILLER_46_119 VPWR VGND sg13g2_decap_8
XFILLER_28_834 VPWR VGND sg13g2_fill_2
XFILLER_39_182 VPWR VGND sg13g2_decap_8
XFILLER_27_322 VPWR VGND sg13g2_decap_8
XFILLER_42_336 VPWR VGND sg13g2_decap_8
XFILLER_15_528 VPWR VGND sg13g2_fill_2
XFILLER_24_32 VPWR VGND sg13g2_decap_8
XFILLER_10_200 VPWR VGND sg13g2_decap_8
XFILLER_7_716 VPWR VGND sg13g2_decap_8
XFILLER_10_277 VPWR VGND sg13g2_decap_8
XFILLER_40_42 VPWR VGND sg13g2_decap_8
XFILLER_3_900 VPWR VGND sg13g2_decap_8
XFILLER_3_933 VPWR VGND sg13g2_fill_1
XFILLER_2_432 VPWR VGND sg13g2_decap_8
XFILLER_49_95 VPWR VGND sg13g2_decap_8
XFILLER_1_14 VPWR VGND sg13g2_decap_8
XFILLER_37_119 VPWR VGND sg13g2_decap_8
XFILLER_18_333 VPWR VGND sg13g2_decap_8
XFILLER_46_675 VPWR VGND sg13g2_decap_4
X_2433__243 VPWR VGND net242 sg13g2_tiehi
XFILLER_45_196 VPWR VGND sg13g2_decap_8
X_1970_ net217 VPWR _0835_ VGND state\[107\] net179 sg13g2_o21ai_1
XFILLER_33_347 VPWR VGND sg13g2_decap_8
X_2522_ net331 VGND VPWR _0468_ state\[84\] clknet_leaf_6_clk sg13g2_dfrbpq_1
XFILLER_5_270 VPWR VGND sg13g2_decap_8
X_2453_ net429 VGND VPWR _0399_ state\[15\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2384_ net340 VGND VPWR _0330_ daisychain\[74\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_1404_ VPWR _0105_ state\[7\] VGND sg13g2_inv_1
X_1335_ VPWR _0101_ state\[76\] VGND sg13g2_inv_1
Xinput2 ui_in[0] net2 VPWR VGND sg13g2_buf_1
XFILLER_37_631 VPWR VGND sg13g2_fill_2
XFILLER_36_196 VPWR VGND sg13g2_decap_8
XFILLER_24_347 VPWR VGND sg13g2_decap_8
XFILLER_4_708 VPWR VGND sg13g2_decap_8
XFILLER_3_207 VPWR VGND sg13g2_decap_8
XFILLER_10_67 VPWR VGND sg13g2_decap_8
XFILLER_47_406 VPWR VGND sg13g2_decap_8
XFILLER_19_32 VPWR VGND sg13g2_decap_8
XFILLER_35_42 VPWR VGND sg13g2_decap_8
XFILLER_42_133 VPWR VGND sg13g2_decap_8
XFILLER_27_196 VPWR VGND sg13g2_decap_8
XFILLER_15_347 VPWR VGND sg13g2_decap_8
XFILLER_11_575 VPWR VGND sg13g2_fill_1
XFILLER_7_535 VPWR VGND sg13g2_decap_8
XFILLER_2_284 VPWR VGND sg13g2_decap_8
XFILLER_18_130 VPWR VGND sg13g2_decap_8
XFILLER_19_697 VPWR VGND sg13g2_fill_1
XFILLER_33_144 VPWR VGND sg13g2_decap_8
X_1953_ VPWR VGND _0822_ net95 _0821_ _0131_ _0358_ net51 sg13g2_a221oi_1
X_1884_ VGND VPWR net144 daisychain\[84\] _0771_ net50 sg13g2_a21oi_1
X_2505_ net467 VGND VPWR _0451_ state\[67\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_2436_ net236 VGND VPWR _0382_ daisychain\[126\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2367_ net374 VGND VPWR _0313_ daisychain\[57\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_2298_ _1020_ net116 state\[122\] VPWR VGND sg13g2_nand2_1
X_1318_ VPWR _0120_ state\[93\] VGND sg13g2_inv_1
XFILLER_25_634 VPWR VGND sg13g2_decap_8
XFILLER_25_645 VPWR VGND sg13g2_fill_1
XFILLER_24_144 VPWR VGND sg13g2_decap_8
XANTENNA_40 VPWR VGND _0182_ sg13g2_antennanp
XFILLER_21_884 VPWR VGND sg13g2_fill_1
XFILLER_21_862 VPWR VGND sg13g2_fill_2
XANTENNA_51 VPWR VGND _0227_ sg13g2_antennanp
XANTENNA_62 VPWR VGND daisychain\[21\] sg13g2_antennanp
XANTENNA_73 VPWR VGND daisychain\[42\] sg13g2_antennanp
XANTENNA_84 VPWR VGND state\[80\] sg13g2_antennanp
XFILLER_21_11 VPWR VGND sg13g2_decap_8
XFILLER_20_361 VPWR VGND sg13g2_decap_8
XANTENNA_95 VPWR VGND _0196_ sg13g2_antennanp
X_2540__400 VPWR VGND net399 sg13g2_tiehi
XFILLER_4_538 VPWR VGND sg13g2_decap_8
XFILLER_21_88 VPWR VGND sg13g2_decap_8
XFILLER_0_766 VPWR VGND sg13g2_fill_1
XFILLER_0_777 VPWR VGND sg13g2_fill_2
XFILLER_47_203 VPWR VGND sg13g2_decap_8
XFILLER_46_63 VPWR VGND sg13g2_decap_8
XFILLER_44_932 VPWR VGND sg13g2_fill_1
XFILLER_29_995 VPWR VGND sg13g2_fill_1
XFILLER_15_144 VPWR VGND sg13g2_decap_8
XFILLER_16_678 VPWR VGND sg13g2_decap_4
XFILLER_31_659 VPWR VGND sg13g2_decap_8
XFILLER_30_158 VPWR VGND sg13g2_decap_8
XFILLER_11_361 VPWR VGND sg13g2_decap_8
XFILLER_7_35 VPWR VGND sg13g2_decap_8
XFILLER_7_343 VPWR VGND sg13g2_decap_8
XFILLER_3_571 VPWR VGND sg13g2_decap_8
X_2221_ VGND VPWR _0764_ _0981_ _0467_ net94 sg13g2_a21oi_1
XFILLER_38_203 VPWR VGND sg13g2_decap_8
XFILLER_23_4 VPWR VGND sg13g2_decap_8
X_2152_ _0947_ net147 state\[49\] VPWR VGND sg13g2_nand2_1
X_2083_ VGND VPWR _0557_ _0912_ _0398_ net75 sg13g2_a21oi_1
XFILLER_19_472 VPWR VGND sg13g2_decap_8
XFILLER_46_280 VPWR VGND sg13g2_decap_8
XFILLER_21_158 VPWR VGND sg13g2_decap_8
X_1936_ VGND VPWR net142 daisychain\[97\] _0810_ net47 sg13g2_a21oi_1
X_1867_ net185 _0235_ _0757_ _0758_ VPWR VGND sg13g2_a21o_1
X_1798_ net231 VPWR _0706_ VGND state\[64\] net207 sg13g2_o21ai_1
X_2419_ net270 VGND VPWR _0365_ daisychain\[109\] clknet_leaf_5_clk sg13g2_dfrbpq_1
XFILLER_29_214 VPWR VGND sg13g2_decap_8
XFILLER_45_718 VPWR VGND sg13g2_fill_1
XFILLER_45_707 VPWR VGND sg13g2_decap_8
XFILLER_44_217 VPWR VGND sg13g2_decap_8
XFILLER_16_11 VPWR VGND sg13g2_decap_8
XFILLER_37_280 VPWR VGND sg13g2_decap_8
XFILLER_40_401 VPWR VGND sg13g2_decap_8
XFILLER_40_445 VPWR VGND sg13g2_decap_4
XFILLER_40_423 VPWR VGND sg13g2_fill_1
XFILLER_16_88 VPWR VGND sg13g2_decap_8
XFILLER_12_158 VPWR VGND sg13g2_decap_8
XFILLER_32_32 VPWR VGND sg13g2_decap_8
XFILLER_5_847 VPWR VGND sg13g2_fill_1
X_2464__386 VPWR VGND net385 sg13g2_tiehi
XFILLER_4_368 VPWR VGND sg13g2_decap_8
XFILLER_0_574 VPWR VGND sg13g2_decap_8
XFILLER_35_217 VPWR VGND sg13g2_decap_8
XFILLER_28_291 VPWR VGND sg13g2_decap_8
XFILLER_43_294 VPWR VGND sg13g2_decap_8
XFILLER_12_681 VPWR VGND sg13g2_decap_4
X_1721_ VPWR VGND _0648_ net77 _0647_ _0194_ _0300_ net31 sg13g2_a221oi_1
XFILLER_8_641 VPWR VGND sg13g2_fill_2
XFILLER_7_140 VPWR VGND sg13g2_decap_8
X_1652_ VGND VPWR net120 daisychain\[26\] _0597_ net27 sg13g2_a21oi_1
X_1583_ net164 _0139_ _0544_ _0545_ VPWR VGND sg13g2_a21o_1
X_2204_ _0973_ net157 state\[75\] VPWR VGND sg13g2_nand2_1
XFILLER_39_523 VPWR VGND sg13g2_decap_4
X_2135_ VGND VPWR _0635_ _0938_ _0424_ net78 sg13g2_a21oi_1
XFILLER_39_545 VPWR VGND sg13g2_decap_8
XFILLER_39_589 VPWR VGND sg13g2_decap_4
XFILLER_26_228 VPWR VGND sg13g2_decap_8
X_2066_ _0904_ net138 state\[6\] VPWR VGND sg13g2_nand2_1
XFILLER_19_291 VPWR VGND sg13g2_decap_8
XFILLER_23_979 VPWR VGND sg13g2_fill_1
XFILLER_23_968 VPWR VGND sg13g2_decap_8
X_1919_ net189 _0249_ _0796_ _0797_ VPWR VGND sg13g2_a21o_1
XFILLER_2_828 VPWR VGND sg13g2_fill_2
XFILLER_27_21 VPWR VGND sg13g2_decap_8
XFILLER_17_217 VPWR VGND sg13g2_decap_8
XFILLER_45_548 VPWR VGND sg13g2_decap_8
XFILLER_27_98 VPWR VGND sg13g2_decap_8
XFILLER_43_42 VPWR VGND sg13g2_decap_8
XFILLER_40_231 VPWR VGND sg13g2_decap_8
XFILLER_13_445 VPWR VGND sg13g2_decap_8
XFILLER_9_438 VPWR VGND sg13g2_decap_8
XFILLER_4_25 VPWR VGND sg13g2_decap_8
XFILLER_4_165 VPWR VGND sg13g2_decap_8
X_2499__246 VPWR VGND net245 sg13g2_tiehi
XFILLER_0_371 VPWR VGND sg13g2_decap_8
XFILLER_49_821 VPWR VGND sg13g2_decap_4
XFILLER_49_876 VPWR VGND sg13g2_fill_2
XFILLER_31_242 VPWR VGND sg13g2_decap_8
X_1704_ VGND VPWR net125 daisychain\[39\] _0636_ net32 sg13g2_a21oi_1
X_1635_ net185 _0171_ _0583_ _0584_ VPWR VGND sg13g2_a21o_1
X_1566_ net218 VPWR _0532_ VGND state\[6\] net183 sg13g2_o21ai_1
X_1497_ VPWR _0192_ daisychain\[42\] VGND sg13g2_inv_1
XFILLER_39_364 VPWR VGND sg13g2_decap_8
X_2118_ _0930_ net148 state\[32\] VPWR VGND sg13g2_nand2_1
X_2049_ VPWR VGND _0894_ net82 _0893_ _0157_ _0382_ net36 sg13g2_a221oi_1
XFILLER_42_529 VPWR VGND sg13g2_decap_4
Xfanout35 net69 net35 VPWR VGND sg13g2_buf_1
Xfanout46 net52 net46 VPWR VGND sg13g2_buf_1
Xfanout24 net35 net24 VPWR VGND sg13g2_buf_1
XFILLER_22_242 VPWR VGND sg13g2_decap_8
Xfanout57 net58 net57 VPWR VGND sg13g2_buf_1
Xfanout68 net69 net68 VPWR VGND sg13g2_buf_1
Xfanout79 net80 net79 VPWR VGND sg13g2_buf_1
XFILLER_23_798 VPWR VGND sg13g2_fill_1
XFILLER_23_787 VPWR VGND sg13g2_decap_8
XFILLER_6_408 VPWR VGND sg13g2_decap_8
XFILLER_6_419 VPWR VGND sg13g2_decap_8
XFILLER_13_67 VPWR VGND sg13g2_decap_8
XFILLER_2_614 VPWR VGND sg13g2_decap_8
XFILLER_1_168 VPWR VGND sg13g2_decap_8
XFILLER_46_802 VPWR VGND sg13g2_decap_4
XFILLER_38_42 VPWR VGND sg13g2_decap_8
XFILLER_46_824 VPWR VGND sg13g2_decap_8
XFILLER_45_301 VPWR VGND sg13g2_decap_8
XFILLER_18_515 VPWR VGND sg13g2_decap_8
XFILLER_45_378 VPWR VGND sg13g2_decap_8
XFILLER_26_592 VPWR VGND sg13g2_decap_8
XFILLER_13_242 VPWR VGND sg13g2_decap_8
XFILLER_9_235 VPWR VGND sg13g2_decap_8
X_1420_ VPWR _0149_ daisychain\[119\] VGND sg13g2_inv_1
XFILLER_5_496 VPWR VGND sg13g2_decap_8
X_1351_ VPWR _0084_ state\[60\] VGND sg13g2_inv_1
XFILLER_48_161 VPWR VGND sg13g2_decap_8
XFILLER_36_301 VPWR VGND sg13g2_decap_8
XFILLER_24_518 VPWR VGND sg13g2_decap_4
XFILLER_36_389 VPWR VGND sg13g2_decap_4
XFILLER_32_595 VPWR VGND sg13g2_fill_2
X_1618_ net212 VPWR _0571_ VGND state\[19\] net172 sg13g2_o21ai_1
Xfanout214 net233 net214 VPWR VGND sg13g2_buf_1
Xfanout203 net204 net203 VPWR VGND sg13g2_buf_1
Xfanout225 net226 net225 VPWR VGND sg13g2_buf_1
X_1549_ VPWR VGND _0519_ net82 _0518_ _0167_ _0257_ net36 sg13g2_a221oi_1
XFILLER_39_161 VPWR VGND sg13g2_decap_8
XFILLER_27_301 VPWR VGND sg13g2_decap_8
XFILLER_15_507 VPWR VGND sg13g2_decap_8
XFILLER_42_315 VPWR VGND sg13g2_decap_8
XFILLER_24_11 VPWR VGND sg13g2_decap_8
XFILLER_24_88 VPWR VGND sg13g2_decap_8
XFILLER_10_256 VPWR VGND sg13g2_decap_8
XFILLER_6_249 VPWR VGND sg13g2_decap_8
XFILLER_40_21 VPWR VGND sg13g2_decap_8
XFILLER_46_1000 VPWR VGND sg13g2_fill_1
XFILLER_40_98 VPWR VGND sg13g2_decap_8
XFILLER_2_411 VPWR VGND sg13g2_decap_8
XFILLER_3_989 VPWR VGND sg13g2_decap_8
XFILLER_2_488 VPWR VGND sg13g2_decap_8
XFILLER_49_74 VPWR VGND sg13g2_decap_8
XFILLER_18_312 VPWR VGND sg13g2_decap_8
XANTENNA_130 VPWR VGND daisychain\[39\] sg13g2_antennanp
XFILLER_45_175 VPWR VGND sg13g2_decap_8
XFILLER_33_326 VPWR VGND sg13g2_decap_8
XFILLER_18_378 VPWR VGND sg13g2_decap_8
X_2521_ net339 VGND VPWR _0467_ state\[83\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2452_ net433 VGND VPWR _0398_ state\[14\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_2383_ net342 VGND VPWR _0329_ daisychain\[73\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_1403_ VPWR _0116_ state\[8\] VGND sg13g2_inv_1
X_1334_ VPWR _0102_ state\[77\] VGND sg13g2_inv_1
XFILLER_37_610 VPWR VGND sg13g2_decap_4
XFILLER_28_109 VPWR VGND sg13g2_decap_8
Xinput3 ui_in[1] net3 VPWR VGND sg13g2_buf_1
XFILLER_36_175 VPWR VGND sg13g2_decap_8
XFILLER_25_838 VPWR VGND sg13g2_fill_1
XFILLER_24_326 VPWR VGND sg13g2_decap_8
XFILLER_10_46 VPWR VGND sg13g2_decap_8
XFILLER_0_926 VPWR VGND sg13g2_decap_8
XFILLER_19_11 VPWR VGND sg13g2_decap_8
XFILLER_19_109 VPWR VGND sg13g2_decap_8
XFILLER_19_88 VPWR VGND sg13g2_decap_8
XFILLER_28_676 VPWR VGND sg13g2_decap_8
XFILLER_28_654 VPWR VGND sg13g2_decap_8
XFILLER_42_112 VPWR VGND sg13g2_decap_8
XFILLER_35_21 VPWR VGND sg13g2_decap_8
XFILLER_27_175 VPWR VGND sg13g2_decap_8
XFILLER_15_326 VPWR VGND sg13g2_decap_8
XFILLER_35_98 VPWR VGND sg13g2_decap_8
XFILLER_42_189 VPWR VGND sg13g2_decap_8
XFILLER_7_514 VPWR VGND sg13g2_decap_8
XFILLER_3_764 VPWR VGND sg13g2_decap_4
XFILLER_2_263 VPWR VGND sg13g2_decap_8
XFILLER_38_429 VPWR VGND sg13g2_decap_4
X_2439__486 VPWR VGND net485 sg13g2_tiehi
XFILLER_19_654 VPWR VGND sg13g2_decap_8
XFILLER_46_473 VPWR VGND sg13g2_fill_1
XFILLER_46_462 VPWR VGND sg13g2_decap_8
XFILLER_19_687 VPWR VGND sg13g2_fill_1
XFILLER_18_186 VPWR VGND sg13g2_decap_8
XFILLER_33_123 VPWR VGND sg13g2_decap_8
X_1952_ VGND VPWR net142 daisychain\[101\] _0822_ net47 sg13g2_a21oi_1
XFILLER_42_690 VPWR VGND sg13g2_fill_2
X_1883_ net189 _0239_ _0769_ _0770_ VPWR VGND sg13g2_a21o_1
X_2504_ net475 VGND VPWR _0450_ state\[66\] clknet_leaf_10_clk sg13g2_dfrbpq_1
XFILLER_44_0 VPWR VGND sg13g2_decap_8
X_2435_ net238 VGND VPWR _0381_ daisychain\[125\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2366_ net376 VGND VPWR _0312_ daisychain\[56\] clknet_leaf_13_clk sg13g2_dfrbpq_1
XFILLER_5_1008 VPWR VGND sg13g2_fill_2
XFILLER_29_407 VPWR VGND sg13g2_fill_2
X_2297_ VGND VPWR _0878_ _1019_ _0505_ net70 sg13g2_a21oi_1
X_1317_ VPWR _0121_ state\[94\] VGND sg13g2_inv_1
XFILLER_24_123 VPWR VGND sg13g2_decap_8
XFILLER_40_627 VPWR VGND sg13g2_fill_1
XANTENNA_30 VPWR VGND _0128_ sg13g2_antennanp
XANTENNA_41 VPWR VGND _0183_ sg13g2_antennanp
XFILLER_20_340 VPWR VGND sg13g2_decap_8
XANTENNA_52 VPWR VGND _0227_ sg13g2_antennanp
XANTENNA_63 VPWR VGND daisychain\[21\] sg13g2_antennanp
XANTENNA_74 VPWR VGND daisychain\[43\] sg13g2_antennanp
XFILLER_21_896 VPWR VGND sg13g2_fill_2
XANTENNA_85 VPWR VGND state\[80\] sg13g2_antennanp
XANTENNA_96 VPWR VGND _0196_ sg13g2_antennanp
XFILLER_4_517 VPWR VGND sg13g2_decap_8
XFILLER_21_67 VPWR VGND sg13g2_decap_8
XFILLER_48_716 VPWR VGND sg13g2_fill_1
XFILLER_47_259 VPWR VGND sg13g2_decap_8
XFILLER_46_42 VPWR VGND sg13g2_decap_8
XFILLER_16_624 VPWR VGND sg13g2_decap_4
XFILLER_43_443 VPWR VGND sg13g2_decap_4
XFILLER_16_646 VPWR VGND sg13g2_decap_8
XFILLER_15_123 VPWR VGND sg13g2_decap_8
XFILLER_43_454 VPWR VGND sg13g2_fill_1
XFILLER_30_137 VPWR VGND sg13g2_decap_8
XFILLER_11_340 VPWR VGND sg13g2_decap_8
XFILLER_7_322 VPWR VGND sg13g2_decap_8
XFILLER_7_14 VPWR VGND sg13g2_decap_8
XFILLER_7_399 VPWR VGND sg13g2_decap_4
X_2402__305 VPWR VGND net304 sg13g2_tiehi
XFILLER_3_550 VPWR VGND sg13g2_decap_8
X_2220_ _0981_ net140 state\[83\] VPWR VGND sg13g2_nand2_1
X_2151_ VGND VPWR _0659_ _0946_ _0432_ net100 sg13g2_a21oi_1
XFILLER_16_4 VPWR VGND sg13g2_decap_8
X_2082_ _0912_ net122 state\[14\] VPWR VGND sg13g2_nand2_1
XFILLER_38_259 VPWR VGND sg13g2_decap_8
XFILLER_34_454 VPWR VGND sg13g2_fill_1
X_1935_ net187 _0253_ _0808_ _0809_ VPWR VGND sg13g2_a21o_1
XFILLER_21_137 VPWR VGND sg13g2_decap_8
XFILLER_30_660 VPWR VGND sg13g2_fill_2
X_1866_ net219 VPWR _0757_ VGND state\[81\] net185 sg13g2_o21ai_1
X_1797_ VPWR VGND _0705_ net111 _0704_ _0215_ _0319_ net64 sg13g2_a221oi_1
X_2418_ net272 VGND VPWR _0364_ daisychain\[108\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2349_ net410 VGND VPWR _0295_ daisychain\[39\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_2492__274 VPWR VGND net273 sg13g2_tiehi
XFILLER_16_67 VPWR VGND sg13g2_decap_8
XFILLER_12_137 VPWR VGND sg13g2_decap_8
XFILLER_40_457 VPWR VGND sg13g2_fill_1
XFILLER_32_11 VPWR VGND sg13g2_decap_8
XFILLER_32_88 VPWR VGND sg13g2_decap_8
XFILLER_21_693 VPWR VGND sg13g2_fill_2
XFILLER_4_347 VPWR VGND sg13g2_decap_8
XFILLER_0_553 VPWR VGND sg13g2_decap_8
XFILLER_29_782 VPWR VGND sg13g2_fill_2
X_2471__358 VPWR VGND net357 sg13g2_tiehi
XFILLER_28_270 VPWR VGND sg13g2_decap_8
XFILLER_16_410 VPWR VGND sg13g2_decap_8
XFILLER_43_273 VPWR VGND sg13g2_decap_8
XFILLER_31_435 VPWR VGND sg13g2_decap_8
X_1720_ VGND VPWR net125 daisychain\[43\] _0648_ net31 sg13g2_a21oi_1
XFILLER_8_664 VPWR VGND sg13g2_decap_8
X_1651_ net170 _0175_ _0595_ _0596_ VPWR VGND sg13g2_a21o_1
XdacH dacH/ON[64] dacH/ONB[64] dacH/ON[65] dacH/ONB[65] dacH/ON[66] dacH/ONB[66] dacH/ON[67]
+ dacH/ONB[67] dacH/ON[68] dacH/ONB[68] dacH/ON[69] dacH/ONB[69] dacH/ON[70] dacH/ONB[70]
+ dacH/ON[71] dacH/ONB[71] dacH/ON[72] dacH/ONB[72] dacH/EN[2] dacH/ENB[2] dacH/ON[73]
+ dacH/ONB[73] dacH/ON[74] dacH/ONB[74] dacH/ON[75] dacH/ONB[75] dacH/ON[76] dacH/ONB[76]
+ dacH/ON[77] dacH/ONB[77] dacH/ON[78] dacH/ONB[78] dacH/ON[79] dacH/ONB[79] dacH/ON[80]
+ dacH/ONB[80] dacH/ON[81] dacH/ONB[81] dacH/ON[82] dacH/ONB[82] dacH/ON[83] dacH/ONB[83]
+ dacH/ON[84] dacH/ONB[84] dacH/ON[85] dacH/ONB[85] dacH/ON[86] dacH/ONB[86] dacH/ON[87]
+ dacH/ONB[87] dacH/ON[88] dacH/ONB[88] dacH/ON[89] dacH/ONB[89] dacH/ON[90] dacH/ONB[90]
+ dacH/ON[91] dacH/ONB[91] dacH/ON[92] dacH/ONB[92] dacH/ON[93] dacH/ONB[93] dacH/ON[94]
+ dacH/ONB[94] dacH/ON[95] dacH/ONB[95] dacH/ON[96] dacH/ONB[96] dacH/ON[97] dacH/ONB[97]
+ dacH/ON[98] dacH/ONB[98] dacH/ON[99] dacH/ONB[99] dacH/ON[100] dacH/ONB[100] dacH/ON[101]
+ dacH/ONB[101] dacH/ON[102] dacH/ONB[102] dacH/ON[103] dacH/ONB[103] dacH/ON[104]
+ dacH/ONB[104] dacH/ON[105] dacH/ONB[105] dacH/ON[106] dacH/ONB[106] dacH/ON[107]
+ dacH/ONB[107] dacH/ON[108] dacH/ONB[108] dacH/ON[109] dacH/ONB[109] dacH/ON[110]
+ dacH/ONB[110] dacH/ON[111] dacH/ONB[111] dacH/ON[112] dacH/ONB[112] dacH/ON[113]
+ dacH/ONB[113] dacH/ON[114] dacH/ONB[114] dacH/ON[115] dacH/ONB[115] dacH/ON[116]
+ dacH/ONB[116] dacH/ON[117] dacH/ONB[117] dacH/ON[118] dacH/ONB[118] dacH/ON[119]
+ dacH/ONB[119] dacH/ON[120] dacH/ONB[120] dacH/ON[121] dacH/ONB[121] dacH/ON[122]
+ dacH/ONB[122] dacH/EN[3] dacH/ENB[3] dacH/ON[123] dacH/ONB[123] dacH/ON[124] dacH/ONB[124]
+ dacH/ON[125] dacH/ONB[125] dacH/ON[126] dacH/ONB[126] dacH/ON[127] dacH/ONB[127]
+ daisychain\[0\] _0128_ daisychain\[1\] _0167_ daisychain\[2\] _0178_ daisychain\[3\]
+ _0189_ daisychain\[4\] _0200_ daisychain\[5\] _0211_ daisychain\[6\] digitalenH.g\[0\].u.OUTP
+ digitalenH.g\[0\].u.OUTN _0222_ daisychain\[7\] _0233_ daisychain\[8\] _0244_ daisychain\[9\]
+ _0255_ daisychain\[10\] _0139_ daisychain\[11\] _0150_ daisychain\[12\] _0159_ daisychain\[13\]
+ _0160_ daisychain\[14\] _0161_ daisychain\[15\] _0162_ daisychain\[16\] _0163_ daisychain\[17\]
+ _0164_ daisychain\[18\] _0165_ daisychain\[19\] _0166_ daisychain\[20\] _0168_ daisychain\[21\]
+ _0169_ daisychain\[22\] _0170_ daisychain\[23\] _0171_ daisychain\[24\] _0172_ daisychain\[25\]
+ _0173_ daisychain\[26\] _0174_ daisychain\[27\] _0175_ daisychain\[28\] _0176_ daisychain\[29\]
+ _0177_ daisychain\[30\] _0179_ daisychain\[31\] _0180_ daisychain\[33\] _0182_ daisychain\[32\]
+ _0181_ daisychain\[34\] _0183_ daisychain\[35\] _0184_ daisychain\[36\] _0185_ daisychain\[37\]
+ _0186_ daisychain\[38\] _0187_ daisychain\[39\] _0188_ daisychain\[40\] _0190_ daisychain\[41\]
+ _0191_ daisychain\[42\] _0192_ daisychain\[43\] _0193_ daisychain\[44\] _0194_ daisychain\[45\]
+ _0195_ daisychain\[46\] _0196_ daisychain\[47\] _0197_ daisychain\[48\] _0198_ daisychain\[49\]
+ _0199_ daisychain\[50\] _0201_ daisychain\[51\] _0202_ daisychain\[52\] _0203_ daisychain\[53\]
+ _0204_ daisychain\[54\] _0205_ daisychain\[55\] _0206_ daisychain\[56\] _0207_ daisychain\[57\]
+ _0208_ daisychain\[58\] _0209_ daisychain\[59\] _0210_ daisychain\[60\] _0212_ daisychain\[61\]
+ _0213_ daisychain\[62\] _0214_ daisychain\[63\] _0215_ digitalenH.g\[1\].u.OUTP
+ digitalenH.g\[1\].u.OUTN VGND VPWR dac128module
XFILLER_7_196 VPWR VGND sg13g2_decap_8
X_1582_ net209 VPWR _0544_ VGND state\[10\] net164 sg13g2_o21ai_1
XFILLER_4_881 VPWR VGND sg13g2_fill_2
XFILLER_39_502 VPWR VGND sg13g2_decap_8
X_2203_ VGND VPWR _0737_ _0972_ _0458_ net107 sg13g2_a21oi_1
X_2134_ _0938_ net126 state\[40\] VPWR VGND sg13g2_nand2_1
XFILLER_27_708 VPWR VGND sg13g2_decap_8
XFILLER_26_207 VPWR VGND sg13g2_decap_8
X_2065_ VGND VPWR _0530_ _0903_ _0389_ net91 sg13g2_a21oi_1
XFILLER_47_590 VPWR VGND sg13g2_decap_8
XFILLER_19_270 VPWR VGND sg13g2_decap_8
XFILLER_23_914 VPWR VGND sg13g2_fill_1
XFILLER_23_903 VPWR VGND sg13g2_decap_4
XFILLER_34_284 VPWR VGND sg13g2_decap_8
XFILLER_23_947 VPWR VGND sg13g2_fill_1
X_1918_ net221 VPWR _0796_ VGND state\[94\] net190 sg13g2_o21ai_1
X_1849_ VPWR VGND _0744_ net109 _0743_ _0229_ _0332_ net62 sg13g2_a221oi_1
XFILLER_18_708 VPWR VGND sg13g2_decap_8
XFILLER_45_527 VPWR VGND sg13g2_decap_8
XFILLER_45_538 VPWR VGND sg13g2_fill_2
XFILLER_27_77 VPWR VGND sg13g2_decap_8
XFILLER_26_763 VPWR VGND sg13g2_fill_2
XFILLER_26_752 VPWR VGND sg13g2_fill_2
XFILLER_43_21 VPWR VGND sg13g2_decap_8
XFILLER_40_210 VPWR VGND sg13g2_decap_8
XFILLER_26_796 VPWR VGND sg13g2_decap_4
XFILLER_25_284 VPWR VGND sg13g2_decap_8
XFILLER_13_424 VPWR VGND sg13g2_decap_8
XFILLER_9_417 VPWR VGND sg13g2_decap_8
XFILLER_43_98 VPWR VGND sg13g2_decap_8
XFILLER_40_287 VPWR VGND sg13g2_decap_8
XFILLER_5_667 VPWR VGND sg13g2_decap_8
XFILLER_4_144 VPWR VGND sg13g2_decap_8
XFILLER_0_350 VPWR VGND sg13g2_decap_8
XFILLER_48_343 VPWR VGND sg13g2_decap_8
XFILLER_48_387 VPWR VGND sg13g2_decap_8
XFILLER_36_527 VPWR VGND sg13g2_fill_2
XFILLER_32_722 VPWR VGND sg13g2_fill_1
XFILLER_16_284 VPWR VGND sg13g2_decap_8
XFILLER_31_221 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_11_clk clknet_2_3__leaf_clk clknet_leaf_11_clk VPWR VGND sg13g2_buf_8
XFILLER_31_298 VPWR VGND sg13g2_decap_8
X_1703_ net173 _0190_ _0634_ _0635_ VPWR VGND sg13g2_a21o_1
XFILLER_8_494 VPWR VGND sg13g2_decap_8
X_1634_ net218 VPWR _0583_ VGND state\[23\] net185 sg13g2_o21ai_1
XdigitalenH.g\[3\].u.inv1 VPWR digitalenH.g\[3\].u.OUTN net7 VGND sg13g2_inv_1
X_1565_ VPWR VGND _0531_ net92 _0530_ _0211_ _0261_ net44 sg13g2_a221oi_1
X_1496_ VPWR _0193_ daisychain\[43\] VGND sg13g2_inv_1
XFILLER_39_343 VPWR VGND sg13g2_decap_8
X_2117_ VGND VPWR _0608_ _0929_ _0415_ net101 sg13g2_a21oi_1
X_2048_ VGND VPWR net129 daisychain\[125\] _0894_ net36 sg13g2_a21oi_1
Xfanout36 net39 net36 VPWR VGND sg13g2_buf_1
Xfanout47 net48 net47 VPWR VGND sg13g2_buf_1
Xfanout25 net35 net25 VPWR VGND sg13g2_buf_1
XFILLER_22_221 VPWR VGND sg13g2_decap_8
Xfanout58 net69 net58 VPWR VGND sg13g2_buf_1
Xfanout69 _0515_ net69 VPWR VGND sg13g2_buf_1
XFILLER_10_449 VPWR VGND sg13g2_decap_8
XFILLER_22_298 VPWR VGND sg13g2_decap_8
XFILLER_13_46 VPWR VGND sg13g2_decap_8
XFILLER_1_147 VPWR VGND sg13g2_decap_8
XFILLER_38_21 VPWR VGND sg13g2_decap_8
XFILLER_46_847 VPWR VGND sg13g2_fill_1
XFILLER_38_98 VPWR VGND sg13g2_decap_8
XFILLER_18_549 VPWR VGND sg13g2_fill_2
XFILLER_45_357 VPWR VGND sg13g2_decap_8
XFILLER_14_722 VPWR VGND sg13g2_fill_1
XFILLER_13_221 VPWR VGND sg13g2_decap_8
XFILLER_9_214 VPWR VGND sg13g2_decap_8
XFILLER_13_298 VPWR VGND sg13g2_decap_8
XFILLER_5_431 VPWR VGND sg13g2_decap_8
XFILLER_5_475 VPWR VGND sg13g2_decap_8
XFILLER_48_7 VPWR VGND sg13g2_decap_8
X_1350_ VPWR _0085_ state\[61\] VGND sg13g2_inv_1
XFILLER_49_641 VPWR VGND sg13g2_decap_8
XFILLER_23_1023 VPWR VGND sg13g2_decap_4
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk clknet_leaf_0_clk VPWR VGND sg13g2_buf_8
XFILLER_48_140 VPWR VGND sg13g2_decap_8
XFILLER_36_357 VPWR VGND sg13g2_decap_8
XFILLER_45_891 VPWR VGND sg13g2_fill_1
XFILLER_17_582 VPWR VGND sg13g2_fill_1
XFILLER_17_571 VPWR VGND sg13g2_decap_8
XFILLER_17_593 VPWR VGND sg13g2_fill_2
X_2410__289 VPWR VGND net288 sg13g2_tiehi
XFILLER_8_291 VPWR VGND sg13g2_decap_8
X_1617_ VPWR VGND _0570_ net76 _0569_ _0165_ _0274_ net30 sg13g2_a221oi_1
Xfanout204 net208 net204 VPWR VGND sg13g2_buf_1
Xfanout226 net228 net226 VPWR VGND sg13g2_buf_1
Xfanout215 net217 net215 VPWR VGND sg13g2_buf_1
X_1548_ VGND VPWR net129 daisychain\[0\] _0519_ net36 sg13g2_a21oi_1
X_1479_ VPWR _0212_ daisychain\[60\] VGND sg13g2_inv_1
XFILLER_39_140 VPWR VGND sg13g2_decap_8
XFILLER_27_357 VPWR VGND sg13g2_decap_8
XFILLER_24_67 VPWR VGND sg13g2_decap_8
XFILLER_23_596 VPWR VGND sg13g2_decap_8
XFILLER_10_235 VPWR VGND sg13g2_decap_8
XFILLER_6_228 VPWR VGND sg13g2_decap_8
XFILLER_40_77 VPWR VGND sg13g2_decap_8
XFILLER_46_1012 VPWR VGND sg13g2_decap_8
XFILLER_3_968 VPWR VGND sg13g2_decap_8
XFILLER_49_53 VPWR VGND sg13g2_decap_8
XFILLER_2_467 VPWR VGND sg13g2_decap_8
XFILLER_1_49 VPWR VGND sg13g2_decap_8
XFILLER_45_154 VPWR VGND sg13g2_decap_8
XFILLER_18_368 VPWR VGND sg13g2_decap_4
XANTENNA_120 VPWR VGND _0185_ sg13g2_antennanp
XANTENNA_131 VPWR VGND daisychain\[41\] sg13g2_antennanp
XFILLER_46_688 VPWR VGND sg13g2_decap_8
XFILLER_33_305 VPWR VGND sg13g2_decap_8
XFILLER_41_371 VPWR VGND sg13g2_decap_8
X_2520_ net347 VGND VPWR _0466_ state\[82\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2451_ net437 VGND VPWR _0397_ state\[13\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1402_ VPWR _0127_ state\[9\] VGND sg13g2_inv_1
X_2382_ net344 VGND VPWR _0328_ daisychain\[72\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_1333_ VPWR _0103_ state\[78\] VGND sg13g2_inv_1
XFILLER_2_990 VPWR VGND sg13g2_decap_8
Xinput4 ui_in[2] net4 VPWR VGND sg13g2_buf_1
XFILLER_37_633 VPWR VGND sg13g2_fill_1
XFILLER_37_677 VPWR VGND sg13g2_decap_4
Xclkbuf_2_1__f_clk clknet_2_1__leaf_clk clknet_0_clk VPWR VGND sg13g2_buf_16
XFILLER_36_154 VPWR VGND sg13g2_decap_8
XFILLER_24_305 VPWR VGND sg13g2_decap_8
XFILLER_32_382 VPWR VGND sg13g2_decap_4
X_2312__485 VPWR VGND net484 sg13g2_tiehi
X_2488__290 VPWR VGND net289 sg13g2_tiehi
XFILLER_10_25 VPWR VGND sg13g2_decap_8
XFILLER_19_67 VPWR VGND sg13g2_decap_8
XFILLER_28_644 VPWR VGND sg13g2_fill_2
XFILLER_43_603 VPWR VGND sg13g2_decap_4
XFILLER_27_154 VPWR VGND sg13g2_decap_8
XFILLER_15_305 VPWR VGND sg13g2_decap_8
XFILLER_43_636 VPWR VGND sg13g2_fill_1
XFILLER_42_168 VPWR VGND sg13g2_decap_8
XFILLER_35_77 VPWR VGND sg13g2_decap_8
XFILLER_30_319 VPWR VGND sg13g2_decap_8
XFILLER_24_883 VPWR VGND sg13g2_decap_4
XFILLER_11_533 VPWR VGND sg13g2_decap_4
XFILLER_23_382 VPWR VGND sg13g2_decap_8
XFILLER_11_588 VPWR VGND sg13g2_decap_8
X_2467__374 VPWR VGND net373 sg13g2_tiehi
XFILLER_3_743 VPWR VGND sg13g2_fill_2
X_2363__383 VPWR VGND net382 sg13g2_tiehi
XFILLER_2_242 VPWR VGND sg13g2_decap_8
XFILLER_46_441 VPWR VGND sg13g2_decap_8
XFILLER_19_644 VPWR VGND sg13g2_fill_2
XFILLER_33_102 VPWR VGND sg13g2_decap_8
XFILLER_18_165 VPWR VGND sg13g2_decap_8
XFILLER_33_179 VPWR VGND sg13g2_decap_8
XFILLER_21_319 VPWR VGND sg13g2_decap_8
X_1951_ net188 _0131_ _0820_ _0821_ VPWR VGND sg13g2_a21o_1
XFILLER_14_382 VPWR VGND sg13g2_decap_8
X_1882_ net221 VPWR _0769_ VGND state\[85\] net189 sg13g2_o21ai_1
X_2446__458 VPWR VGND net457 sg13g2_tiehi
X_2503_ net483 VGND VPWR _0449_ state\[65\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_2409__291 VPWR VGND net290 sg13g2_tiehi
X_2434_ net240 VGND VPWR _0380_ daisychain\[124\] clknet_leaf_18_clk sg13g2_dfrbpq_1
X_2365_ net378 VGND VPWR _0311_ daisychain\[55\] clknet_leaf_11_clk sg13g2_dfrbpq_1
XFILLER_37_0 VPWR VGND sg13g2_decap_8
X_1316_ VPWR _0122_ state\[95\] VGND sg13g2_inv_1
X_2296_ _1019_ net117 state\[121\] VPWR VGND sg13g2_nand2_1
XFILLER_2_81 VPWR VGND sg13g2_decap_8
XFILLER_24_102 VPWR VGND sg13g2_decap_8
XFILLER_12_319 VPWR VGND sg13g2_decap_8
XFILLER_33_680 VPWR VGND sg13g2_fill_2
XFILLER_24_179 VPWR VGND sg13g2_decap_8
XANTENNA_20 VPWR VGND daisychain\[31\] sg13g2_antennanp
XANTENNA_31 VPWR VGND _0139_ sg13g2_antennanp
XFILLER_21_875 VPWR VGND sg13g2_fill_2
XFILLER_21_842 VPWR VGND sg13g2_fill_1
XANTENNA_42 VPWR VGND _0186_ sg13g2_antennanp
XANTENNA_53 VPWR VGND _0228_ sg13g2_antennanp
XANTENNA_64 VPWR VGND daisychain\[24\] sg13g2_antennanp
XANTENNA_75 VPWR VGND daisychain\[43\] sg13g2_antennanp
XANTENNA_86 VPWR VGND state\[9\] sg13g2_antennanp
XANTENNA_97 VPWR VGND _0202_ sg13g2_antennanp
XFILLER_21_46 VPWR VGND sg13g2_decap_8
XFILLER_0_702 VPWR VGND sg13g2_decap_8
XFILLER_0_757 VPWR VGND sg13g2_decap_8
XFILLER_0_779 VPWR VGND sg13g2_fill_1
XFILLER_47_238 VPWR VGND sg13g2_decap_8
XFILLER_46_21 VPWR VGND sg13g2_decap_8
XFILLER_28_430 VPWR VGND sg13g2_decap_8
XFILLER_44_923 VPWR VGND sg13g2_fill_2
XFILLER_44_901 VPWR VGND sg13g2_fill_1
XFILLER_46_98 VPWR VGND sg13g2_decap_8
XFILLER_15_102 VPWR VGND sg13g2_decap_8
XFILLER_44_989 VPWR VGND sg13g2_fill_1
XFILLER_30_116 VPWR VGND sg13g2_decap_8
XFILLER_15_179 VPWR VGND sg13g2_decap_8
XFILLER_7_301 VPWR VGND sg13g2_decap_8
XFILLER_11_396 VPWR VGND sg13g2_decap_8
XFILLER_7_378 VPWR VGND sg13g2_decap_8
X_2150_ _0946_ net147 state\[48\] VPWR VGND sg13g2_nand2_1
X_2081_ VGND VPWR _0554_ _0911_ _0397_ net75 sg13g2_a21oi_1
XFILLER_38_238 VPWR VGND sg13g2_decap_8
XFILLER_34_433 VPWR VGND sg13g2_decap_8
XFILLER_22_639 VPWR VGND sg13g2_decap_4
XFILLER_21_116 VPWR VGND sg13g2_decap_8
X_1934_ net220 VPWR _0808_ VGND state\[98\] net187 sg13g2_o21ai_1
X_1865_ VPWR VGND _0756_ net108 _0755_ _0234_ _0336_ net60 sg13g2_a221oi_1
X_2563__424 VPWR VGND net423 sg13g2_tiehi
X_1796_ VGND VPWR net158 daisychain\[62\] _0705_ net64 sg13g2_a21oi_1
X_2417_ net274 VGND VPWR _0363_ daisychain\[107\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2348_ net412 VGND VPWR _0294_ daisychain\[38\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_2279_ VGND VPWR _0851_ _1010_ _0496_ net85 sg13g2_a21oi_1
XFILLER_29_249 VPWR VGND sg13g2_decap_8
XFILLER_16_46 VPWR VGND sg13g2_decap_8
XFILLER_12_116 VPWR VGND sg13g2_decap_8
XFILLER_8_109 VPWR VGND sg13g2_decap_8
XFILLER_32_67 VPWR VGND sg13g2_decap_8
XFILLER_20_193 VPWR VGND sg13g2_decap_8
XFILLER_5_838 VPWR VGND sg13g2_fill_1
XFILLER_4_326 VPWR VGND sg13g2_decap_8
X_2501__238 VPWR VGND net237 sg13g2_tiehi
XFILLER_0_532 VPWR VGND sg13g2_decap_8
XFILLER_48_525 VPWR VGND sg13g2_fill_2
XFILLER_29_794 VPWR VGND sg13g2_fill_1
XFILLER_43_252 VPWR VGND sg13g2_decap_8
XFILLER_11_193 VPWR VGND sg13g2_decap_8
X_1650_ net211 VPWR _0595_ VGND state\[27\] net170 sg13g2_o21ai_1
XFILLER_7_175 VPWR VGND sg13g2_decap_8
X_1581_ VPWR VGND _0543_ net71 _0542_ _0255_ _0265_ net25 sg13g2_a221oi_1
X_2202_ _0972_ net154 state\[74\] VPWR VGND sg13g2_nand2_1
X_2133_ VGND VPWR _0632_ _0937_ _0423_ net74 sg13g2_a21oi_1
XFILLER_39_569 VPWR VGND sg13g2_fill_2
X_2064_ _0903_ net138 state\[5\] VPWR VGND sg13g2_nand2_1
XFILLER_34_263 VPWR VGND sg13g2_decap_8
XFILLER_22_403 VPWR VGND sg13g2_decap_4
XFILLER_10_609 VPWR VGND sg13g2_decap_8
X_1917_ VPWR VGND _0795_ net108 _0794_ _0248_ _0349_ net60 sg13g2_a221oi_1
X_1848_ VGND VPWR net156 daisychain\[75\] _0744_ net62 sg13g2_a21oi_1
X_1779_ net197 _0210_ _0691_ _0692_ VPWR VGND sg13g2_a21o_1
XFILLER_1_329 VPWR VGND sg13g2_decap_8
X_2420__269 VPWR VGND net268 sg13g2_tiehi
XFILLER_38_591 VPWR VGND sg13g2_decap_4
XFILLER_27_56 VPWR VGND sg13g2_decap_8
XFILLER_25_263 VPWR VGND sg13g2_decap_8
XFILLER_13_403 VPWR VGND sg13g2_decap_8
XFILLER_13_458 VPWR VGND sg13g2_decap_8
XFILLER_43_77 VPWR VGND sg13g2_decap_8
XFILLER_40_266 VPWR VGND sg13g2_decap_8
XFILLER_4_123 VPWR VGND sg13g2_decap_8
XFILLER_48_322 VPWR VGND sg13g2_decap_8
XFILLER_48_366 VPWR VGND sg13g2_decap_8
XFILLER_31_200 VPWR VGND sg13g2_decap_8
XFILLER_16_263 VPWR VGND sg13g2_decap_8
XFILLER_31_277 VPWR VGND sg13g2_decap_8
XFILLER_12_480 VPWR VGND sg13g2_decap_8
X_1702_ net213 VPWR _0634_ VGND state\[40\] net173 sg13g2_o21ai_1
XFILLER_8_473 VPWR VGND sg13g2_decap_8
X_1633_ VPWR VGND _0582_ net91 _0581_ _0170_ _0278_ net44 sg13g2_a221oi_1
XdigitalenH.g\[3\].u.inv2 VPWR digitalenH.g\[3\].u.OUTP digitalenH.g\[3\].u.OUTN VGND
+ sg13g2_inv_1
X_1564_ VGND VPWR net138 daisychain\[4\] _0531_ net44 sg13g2_a21oi_1
X_1495_ VPWR _0194_ daisychain\[44\] VGND sg13g2_inv_1
XFILLER_4_690 VPWR VGND sg13g2_decap_8
XFILLER_39_322 VPWR VGND sg13g2_decap_8
X_2116_ _0929_ net148 state\[31\] VPWR VGND sg13g2_nand2_1
X_2047_ net176 _0157_ _0892_ _0893_ VPWR VGND sg13g2_a21o_1
XFILLER_23_723 VPWR VGND sg13g2_fill_2
XFILLER_22_200 VPWR VGND sg13g2_decap_8
Xfanout37 net39 net37 VPWR VGND sg13g2_buf_1
Xfanout26 net35 net26 VPWR VGND sg13g2_buf_1
Xfanout48 net51 net48 VPWR VGND sg13g2_buf_1
Xfanout59 net63 net59 VPWR VGND sg13g2_buf_1
XFILLER_22_277 VPWR VGND sg13g2_decap_8
XFILLER_10_428 VPWR VGND sg13g2_decap_8
XFILLER_13_25 VPWR VGND sg13g2_decap_8
XFILLER_2_649 VPWR VGND sg13g2_decap_8
XFILLER_1_126 VPWR VGND sg13g2_decap_8
X_2322__465 VPWR VGND net464 sg13g2_tiehi
XFILLER_38_77 VPWR VGND sg13g2_decap_8
XFILLER_46_859 VPWR VGND sg13g2_decap_8
XFILLER_45_336 VPWR VGND sg13g2_decap_8
XFILLER_13_200 VPWR VGND sg13g2_decap_8
XFILLER_41_520 VPWR VGND sg13g2_decap_4
XFILLER_13_277 VPWR VGND sg13g2_decap_8
XFILLER_5_410 VPWR VGND sg13g2_decap_8
XFILLER_5_454 VPWR VGND sg13g2_decap_8
XFILLER_49_620 VPWR VGND sg13g2_decap_8
XFILLER_49_686 VPWR VGND sg13g2_decap_8
XFILLER_36_336 VPWR VGND sg13g2_decap_8
XFILLER_48_196 VPWR VGND sg13g2_decap_8
X_2373__363 VPWR VGND net362 sg13g2_tiehi
XFILLER_32_531 VPWR VGND sg13g2_fill_2
XFILLER_32_575 VPWR VGND sg13g2_fill_2
XFILLER_32_597 VPWR VGND sg13g2_fill_1
XFILLER_8_270 VPWR VGND sg13g2_decap_8
X_1616_ VGND VPWR net123 daisychain\[17\] _0570_ net30 sg13g2_a21oi_1
Xfanout205 net208 net205 VPWR VGND sg13g2_buf_1
XFILLER_5_81 VPWR VGND sg13g2_decap_8
Xfanout227 net228 net227 VPWR VGND sg13g2_buf_1
Xfanout216 net217 net216 VPWR VGND sg13g2_buf_1
X_1547_ net176 _0167_ _0517_ _0518_ VPWR VGND sg13g2_a21o_1
X_1478_ VPWR _0213_ daisychain\[61\] VGND sg13g2_inv_1
X_2419__271 VPWR VGND net270 sg13g2_tiehi
XFILLER_39_196 VPWR VGND sg13g2_decap_8
XFILLER_27_336 VPWR VGND sg13g2_decap_8
XFILLER_24_46 VPWR VGND sg13g2_decap_8
XFILLER_10_214 VPWR VGND sg13g2_decap_8
XFILLER_6_207 VPWR VGND sg13g2_decap_8
XFILLER_40_56 VPWR VGND sg13g2_decap_8
XFILLER_6_4 VPWR VGND sg13g2_decap_8
XFILLER_2_446 VPWR VGND sg13g2_decap_8
XFILLER_49_32 VPWR VGND sg13g2_decap_8
XFILLER_1_28 VPWR VGND sg13g2_decap_8
XFILLER_45_133 VPWR VGND sg13g2_decap_8
XFILLER_18_347 VPWR VGND sg13g2_decap_8
XANTENNA_110 VPWR VGND daisychain\[41\] sg13g2_antennanp
XANTENNA_121 VPWR VGND _0193_ sg13g2_antennanp
XANTENNA_132 VPWR VGND daisychain\[45\] sg13g2_antennanp
XFILLER_41_350 VPWR VGND sg13g2_decap_8
X_2450_ net441 VGND VPWR _0396_ state\[12\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1401_ VPWR _0011_ state\[10\] VGND sg13g2_inv_1
XFILLER_5_284 VPWR VGND sg13g2_decap_8
X_2381_ net346 VGND VPWR _0327_ daisychain\[71\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_1332_ VPWR _0104_ state\[79\] VGND sg13g2_inv_1
XFILLER_1_490 VPWR VGND sg13g2_decap_8
Xinput5 ui_in[3] net5 VPWR VGND sg13g2_buf_1
XFILLER_49_483 VPWR VGND sg13g2_decap_8
XFILLER_37_667 VPWR VGND sg13g2_decap_4
XFILLER_36_133 VPWR VGND sg13g2_decap_8
XFILLER_25_807 VPWR VGND sg13g2_fill_1
XFILLER_32_361 VPWR VGND sg13g2_decap_8
XFILLER_20_501 VPWR VGND sg13g2_decap_8
XFILLER_19_46 VPWR VGND sg13g2_decap_8
X_2495__262 VPWR VGND net261 sg13g2_tiehi
XFILLER_27_133 VPWR VGND sg13g2_decap_8
XFILLER_43_648 VPWR VGND sg13g2_decap_8
XFILLER_35_56 VPWR VGND sg13g2_decap_8
XFILLER_42_147 VPWR VGND sg13g2_decap_8
XFILLER_11_501 VPWR VGND sg13g2_decap_8
XFILLER_23_361 VPWR VGND sg13g2_decap_8
XFILLER_11_556 VPWR VGND sg13g2_decap_8
XFILLER_3_733 VPWR VGND sg13g2_decap_4
XFILLER_2_221 VPWR VGND sg13g2_decap_8
XFILLER_3_799 VPWR VGND sg13g2_fill_2
XFILLER_2_298 VPWR VGND sg13g2_decap_8
X_2474__346 VPWR VGND net345 sg13g2_tiehi
XFILLER_46_420 VPWR VGND sg13g2_decap_8
XFILLER_46_486 VPWR VGND sg13g2_decap_8
XFILLER_18_144 VPWR VGND sg13g2_decap_8
XFILLER_33_158 VPWR VGND sg13g2_decap_8
X_1950_ net220 VPWR _0820_ VGND state\[102\] net188 sg13g2_o21ai_1
XFILLER_42_692 VPWR VGND sg13g2_fill_1
XFILLER_14_361 VPWR VGND sg13g2_decap_8
X_1881_ VPWR VGND _0768_ net97 _0767_ _0238_ _0340_ net49 sg13g2_a221oi_1
X_2502_ net VGND VPWR _0448_ state\[64\] clknet_leaf_11_clk sg13g2_dfrbpq_1
XFILLER_6_582 VPWR VGND sg13g2_decap_4
X_2433_ net242 VGND VPWR _0379_ daisychain\[123\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2364_ net380 VGND VPWR _0310_ daisychain\[54\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_1315_ VPWR _0123_ state\[96\] VGND sg13g2_inv_1
X_2295_ VGND VPWR _0875_ _1018_ _0504_ net83 sg13g2_a21oi_1
XFILLER_2_60 VPWR VGND sg13g2_decap_8
XFILLER_49_291 VPWR VGND sg13g2_decap_8
XFILLER_25_615 VPWR VGND sg13g2_decap_8
XFILLER_24_158 VPWR VGND sg13g2_decap_8
XFILLER_33_692 VPWR VGND sg13g2_decap_4
XANTENNA_10 VPWR VGND _0176_ sg13g2_antennanp
XANTENNA_21 VPWR VGND daisychain\[31\] sg13g2_antennanp
XANTENNA_32 VPWR VGND _0143_ sg13g2_antennanp
XFILLER_21_854 VPWR VGND sg13g2_fill_1
XANTENNA_43 VPWR VGND _0187_ sg13g2_antennanp
XANTENNA_54 VPWR VGND _0239_ sg13g2_antennanp
XANTENNA_65 VPWR VGND daisychain\[28\] sg13g2_antennanp
XFILLER_20_375 VPWR VGND sg13g2_decap_8
XANTENNA_76 VPWR VGND daisychain\[6\] sg13g2_antennanp
XANTENNA_87 VPWR VGND _0180_ sg13g2_antennanp
XANTENNA_98 VPWR VGND _0239_ sg13g2_antennanp
XFILLER_21_25 VPWR VGND sg13g2_decap_8
XFILLER_0_725 VPWR VGND sg13g2_fill_2
XFILLER_0_736 VPWR VGND sg13g2_decap_8
XFILLER_47_217 VPWR VGND sg13g2_decap_8
XFILLER_29_943 VPWR VGND sg13g2_fill_1
XFILLER_46_77 VPWR VGND sg13g2_decap_8
XFILLER_29_976 VPWR VGND sg13g2_fill_1
XFILLER_43_412 VPWR VGND sg13g2_decap_8
XFILLER_43_467 VPWR VGND sg13g2_decap_8
XFILLER_15_158 VPWR VGND sg13g2_decap_8
X_2430__249 VPWR VGND net248 sg13g2_tiehi
XFILLER_43_478 VPWR VGND sg13g2_fill_2
XFILLER_11_375 VPWR VGND sg13g2_fill_2
XFILLER_7_49 VPWR VGND sg13g2_decap_8
XFILLER_7_357 VPWR VGND sg13g2_decap_8
XFILLER_3_585 VPWR VGND sg13g2_decap_8
XFILLER_38_217 VPWR VGND sg13g2_decap_8
X_2080_ _0911_ net122 state\[13\] VPWR VGND sg13g2_nand2_1
XFILLER_47_751 VPWR VGND sg13g2_decap_8
XFILLER_46_294 VPWR VGND sg13g2_decap_8
XFILLER_34_467 VPWR VGND sg13g2_decap_8
XFILLER_34_445 VPWR VGND sg13g2_decap_8
XFILLER_22_629 VPWR VGND sg13g2_fill_1
X_1933_ VPWR VGND _0807_ net96 _0806_ _0252_ _0353_ net47 sg13g2_a221oi_1
X_1864_ VGND VPWR net155 daisychain\[79\] _0756_ net60 sg13g2_a21oi_1
X_1795_ net200 _0215_ _0703_ _0704_ VPWR VGND sg13g2_a21o_1
X_2416_ net276 VGND VPWR _0362_ daisychain\[106\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2347_ net414 VGND VPWR _0293_ daisychain\[37\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_2278_ _1010_ net131 state\[112\] VPWR VGND sg13g2_nand2_1
XFILLER_29_228 VPWR VGND sg13g2_decap_8
XFILLER_37_294 VPWR VGND sg13g2_decap_8
XFILLER_16_25 VPWR VGND sg13g2_decap_8
XFILLER_26_968 VPWR VGND sg13g2_fill_2
XFILLER_40_415 VPWR VGND sg13g2_fill_1
XFILLER_32_46 VPWR VGND sg13g2_decap_8
XFILLER_21_695 VPWR VGND sg13g2_fill_1
XFILLER_20_172 VPWR VGND sg13g2_decap_8
XFILLER_4_305 VPWR VGND sg13g2_decap_8
XFILLER_0_511 VPWR VGND sg13g2_decap_8
XFILLER_0_588 VPWR VGND sg13g2_decap_8
XFILLER_48_559 VPWR VGND sg13g2_fill_2
XFILLER_29_740 VPWR VGND sg13g2_decap_8
XFILLER_29_773 VPWR VGND sg13g2_fill_1
XFILLER_29_762 VPWR VGND sg13g2_decap_8
XFILLER_29_751 VPWR VGND sg13g2_fill_1
XFILLER_44_765 VPWR VGND sg13g2_fill_1
XFILLER_44_754 VPWR VGND sg13g2_decap_8
XFILLER_44_743 VPWR VGND sg13g2_decap_8
XFILLER_43_231 VPWR VGND sg13g2_decap_8
XFILLER_16_456 VPWR VGND sg13g2_decap_8
XFILLER_44_787 VPWR VGND sg13g2_decap_8
X_2332__445 VPWR VGND net444 sg13g2_tiehi
XFILLER_31_459 VPWR VGND sg13g2_decap_8
XFILLER_11_172 VPWR VGND sg13g2_decap_8
XFILLER_7_154 VPWR VGND sg13g2_decap_8
X_1580_ VGND VPWR net118 daisychain\[8\] _0543_ net25 sg13g2_a21oi_1
XFILLER_4_883 VPWR VGND sg13g2_fill_1
XFILLER_3_382 VPWR VGND sg13g2_decap_8
X_2201_ VGND VPWR _0734_ _0971_ _0457_ net110 sg13g2_a21oi_1
XFILLER_21_4 VPWR VGND sg13g2_decap_8
X_2132_ _0937_ net121 state\[39\] VPWR VGND sg13g2_nand2_1
X_2063_ VGND VPWR _0527_ _0902_ _0388_ net84 sg13g2_a21oi_1
XFILLER_34_242 VPWR VGND sg13g2_decap_8
XFILLER_23_938 VPWR VGND sg13g2_fill_1
X_1916_ VGND VPWR net155 daisychain\[92\] _0795_ net60 sg13g2_a21oi_1
X_1847_ net204 _0229_ _0742_ _0743_ VPWR VGND sg13g2_a21o_1
XFILLER_8_81 VPWR VGND sg13g2_decap_8
X_2383__343 VPWR VGND net342 sg13g2_tiehi
X_1778_ net227 VPWR _0691_ VGND state\[59\] net197 sg13g2_o21ai_1
XFILLER_1_308 VPWR VGND sg13g2_decap_8
XFILLER_27_35 VPWR VGND sg13g2_decap_8
XFILLER_26_754 VPWR VGND sg13g2_fill_1
XFILLER_25_242 VPWR VGND sg13g2_decap_8
XFILLER_43_56 VPWR VGND sg13g2_decap_8
XFILLER_40_245 VPWR VGND sg13g2_decap_8
XFILLER_22_993 VPWR VGND sg13g2_decap_4
X_2429__251 VPWR VGND net250 sg13g2_tiehi
XFILLER_5_603 VPWR VGND sg13g2_decap_8
XFILLER_4_102 VPWR VGND sg13g2_decap_8
XFILLER_4_39 VPWR VGND sg13g2_decap_8
XFILLER_4_179 VPWR VGND sg13g2_decap_8
XFILLER_48_301 VPWR VGND sg13g2_decap_8
XFILLER_0_385 VPWR VGND sg13g2_decap_8
XFILLER_49_846 VPWR VGND sg13g2_fill_1
XFILLER_36_529 VPWR VGND sg13g2_fill_1
XFILLER_16_242 VPWR VGND sg13g2_decap_8
XFILLER_31_256 VPWR VGND sg13g2_decap_8
X_1701_ VPWR VGND _0633_ net74 _0632_ _0188_ _0295_ net28 sg13g2_a221oi_1
XFILLER_8_452 VPWR VGND sg13g2_decap_8
X_1632_ VGND VPWR net138 daisychain\[21\] _0582_ net44 sg13g2_a21oi_1
X_1563_ net184 _0211_ _0529_ _0530_ VPWR VGND sg13g2_a21o_1
X_1494_ VPWR _0195_ daisychain\[45\] VGND sg13g2_inv_1
XFILLER_39_301 VPWR VGND sg13g2_decap_8
XFILLER_27_518 VPWR VGND sg13g2_decap_8
X_2115_ VGND VPWR _0605_ _0928_ _0414_ net100 sg13g2_a21oi_1
XFILLER_27_529 VPWR VGND sg13g2_fill_1
X_2046_ net215 VPWR _0892_ VGND state\[126\] net176 sg13g2_o21ai_1
Xfanout38 net39 net38 VPWR VGND sg13g2_buf_1
Xfanout27 net34 net27 VPWR VGND sg13g2_buf_1
XFILLER_23_735 VPWR VGND sg13g2_fill_2
XFILLER_10_407 VPWR VGND sg13g2_decap_8
Xfanout49 net51 net49 VPWR VGND sg13g2_buf_1
XFILLER_22_256 VPWR VGND sg13g2_decap_8
XFILLER_2_628 VPWR VGND sg13g2_decap_8
XFILLER_1_105 VPWR VGND sg13g2_decap_8
XFILLER_49_109 VPWR VGND sg13g2_decap_8
XFILLER_38_56 VPWR VGND sg13g2_decap_8
XFILLER_46_838 VPWR VGND sg13g2_decap_8
XFILLER_45_315 VPWR VGND sg13g2_decap_8
XFILLER_13_256 VPWR VGND sg13g2_decap_8
XFILLER_41_576 VPWR VGND sg13g2_decap_4
XFILLER_9_249 VPWR VGND sg13g2_decap_8
XFILLER_41_598 VPWR VGND sg13g2_decap_4
XFILLER_0_182 VPWR VGND sg13g2_decap_8
XFILLER_49_698 VPWR VGND sg13g2_fill_2
XFILLER_48_175 VPWR VGND sg13g2_decap_8
XFILLER_36_315 VPWR VGND sg13g2_decap_8
XFILLER_45_871 VPWR VGND sg13g2_fill_1
XFILLER_17_551 VPWR VGND sg13g2_fill_1
XFILLER_44_392 VPWR VGND sg13g2_decap_8
X_2449__446 VPWR VGND net445 sg13g2_tiehi
X_1615_ net172 _0165_ _0568_ _0569_ VPWR VGND sg13g2_a21o_1
X_1546_ net215 VPWR _0517_ VGND state\[1\] net176 sg13g2_o21ai_1
XFILLER_5_60 VPWR VGND sg13g2_decap_8
Xfanout228 net233 net228 VPWR VGND sg13g2_buf_1
Xfanout217 net223 net217 VPWR VGND sg13g2_buf_1
Xfanout206 net208 net206 VPWR VGND sg13g2_buf_1
X_1477_ VPWR _0214_ daisychain\[62\] VGND sg13g2_inv_1
XFILLER_39_175 VPWR VGND sg13g2_decap_8
XFILLER_27_315 VPWR VGND sg13g2_decap_8
X_2029_ VPWR VGND _0879_ net70 _0878_ _0152_ _0377_ net24 sg13g2_a221oi_1
XFILLER_42_329 VPWR VGND sg13g2_decap_8
XFILLER_24_25 VPWR VGND sg13g2_decap_8
XFILLER_23_587 VPWR VGND sg13g2_decap_4
XFILLER_40_35 VPWR VGND sg13g2_decap_8
XFILLER_49_11 VPWR VGND sg13g2_decap_8
XFILLER_2_425 VPWR VGND sg13g2_decap_8
XFILLER_49_88 VPWR VGND sg13g2_decap_8
XFILLER_18_326 VPWR VGND sg13g2_decap_8
XANTENNA_100 VPWR VGND _0240_ sg13g2_antennanp
XFILLER_46_668 VPWR VGND sg13g2_fill_2
XFILLER_45_112 VPWR VGND sg13g2_decap_8
XANTENNA_111 VPWR VGND daisychain\[41\] sg13g2_antennanp
XANTENNA_122 VPWR VGND _0241_ sg13g2_antennanp
XANTENNA_133 VPWR VGND daisychain\[45\] sg13g2_antennanp
XFILLER_46_679 VPWR VGND sg13g2_fill_2
XFILLER_45_189 VPWR VGND sg13g2_decap_8
XFILLER_5_263 VPWR VGND sg13g2_decap_8
X_1400_ VPWR _0022_ state\[11\] VGND sg13g2_inv_1
X_2380_ net348 VGND VPWR _0326_ daisychain\[70\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_1331_ VPWR _0106_ state\[80\] VGND sg13g2_inv_1
Xinput6 ui_in[4] net6 VPWR VGND sg13g2_buf_1
XFILLER_49_473 VPWR VGND sg13g2_fill_2
XFILLER_36_112 VPWR VGND sg13g2_decap_8
XFILLER_36_189 VPWR VGND sg13g2_decap_8
XFILLER_32_340 VPWR VGND sg13g2_decap_8
X_2503__484 VPWR VGND net483 sg13g2_tiehi
X_1529_ VPWR _0139_ daisychain\[10\] VGND sg13g2_inv_1
XFILLER_19_25 VPWR VGND sg13g2_decap_8
XFILLER_27_112 VPWR VGND sg13g2_decap_8
XFILLER_42_126 VPWR VGND sg13g2_decap_8
XFILLER_35_35 VPWR VGND sg13g2_decap_8
XFILLER_27_189 VPWR VGND sg13g2_decap_8
XFILLER_23_340 VPWR VGND sg13g2_decap_8
XFILLER_11_546 VPWR VGND sg13g2_fill_1
XFILLER_7_528 VPWR VGND sg13g2_decap_8
XFILLER_3_745 VPWR VGND sg13g2_fill_1
XFILLER_2_200 VPWR VGND sg13g2_decap_8
XFILLER_2_277 VPWR VGND sg13g2_decap_8
XFILLER_47_922 VPWR VGND sg13g2_fill_2
XFILLER_19_635 VPWR VGND sg13g2_decap_4
XFILLER_18_123 VPWR VGND sg13g2_decap_8
X_2515__388 VPWR VGND net387 sg13g2_tiehi
XFILLER_33_137 VPWR VGND sg13g2_decap_8
XFILLER_14_340 VPWR VGND sg13g2_decap_8
X_1880_ VGND VPWR net144 daisychain\[83\] _0768_ net49 sg13g2_a21oi_1
XFILLER_10_590 VPWR VGND sg13g2_fill_2
X_2481__318 VPWR VGND net317 sg13g2_tiehi
X_2501_ net237 VGND VPWR _0447_ state\[63\] clknet_leaf_13_clk sg13g2_dfrbpq_1
XFILLER_6_561 VPWR VGND sg13g2_decap_8
X_2342__425 VPWR VGND net424 sg13g2_tiehi
X_2432_ net244 VGND VPWR _0378_ daisychain\[122\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2363_ net382 VGND VPWR _0309_ daisychain\[53\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_1314_ VPWR _0124_ state\[97\] VGND sg13g2_inv_1
X_2294_ _1018_ net130 state\[120\] VPWR VGND sg13g2_nand2_1
XFILLER_49_270 VPWR VGND sg13g2_decap_8
XFILLER_24_137 VPWR VGND sg13g2_decap_8
XANTENNA_11 VPWR VGND _0181_ sg13g2_antennanp
XANTENNA_22 VPWR VGND daisychain\[31\] sg13g2_antennanp
XANTENNA_33 VPWR VGND _0150_ sg13g2_antennanp
XANTENNA_44 VPWR VGND _0190_ sg13g2_antennanp
XANTENNA_55 VPWR VGND _0239_ sg13g2_antennanp
XANTENNA_66 VPWR VGND daisychain\[28\] sg13g2_antennanp
XFILLER_21_888 VPWR VGND sg13g2_fill_1
XFILLER_20_354 VPWR VGND sg13g2_decap_8
XANTENNA_77 VPWR VGND daisychain\[7\] sg13g2_antennanp
XANTENNA_88 VPWR VGND _0183_ sg13g2_antennanp
XANTENNA_99 VPWR VGND _0239_ sg13g2_antennanp
X_2393__323 VPWR VGND net322 sg13g2_tiehi
XFILLER_46_56 VPWR VGND sg13g2_decap_8
XFILLER_29_988 VPWR VGND sg13g2_fill_2
XFILLER_15_137 VPWR VGND sg13g2_decap_8
XFILLER_11_354 VPWR VGND sg13g2_decap_8
XFILLER_7_28 VPWR VGND sg13g2_decap_8
XFILLER_7_336 VPWR VGND sg13g2_decap_8
XFILLER_11_81 VPWR VGND sg13g2_decap_8
XFILLER_3_564 VPWR VGND sg13g2_decap_8
XFILLER_19_465 VPWR VGND sg13g2_decap_8
XFILLER_46_273 VPWR VGND sg13g2_decap_8
XFILLER_19_498 VPWR VGND sg13g2_decap_8
XFILLER_15_682 VPWR VGND sg13g2_fill_2
X_1932_ VGND VPWR net142 daisychain\[96\] _0807_ net47 sg13g2_a21oi_1
X_1863_ net203 _0234_ _0754_ _0755_ VPWR VGND sg13g2_a21o_1
X_1794_ net228 VPWR _0703_ VGND state\[63\] net198 sg13g2_o21ai_1
XFILLER_42_0 VPWR VGND sg13g2_decap_8
X_2415_ net278 VGND VPWR _0361_ daisychain\[105\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2346_ net416 VGND VPWR _0292_ daisychain\[36\] clknet_leaf_17_clk sg13g2_dfrbpq_1
XFILLER_29_207 VPWR VGND sg13g2_decap_8
X_2277_ VGND VPWR _0848_ _1009_ _0495_ net85 sg13g2_a21oi_1
XFILLER_37_273 VPWR VGND sg13g2_decap_8
XFILLER_40_427 VPWR VGND sg13g2_decap_4
XFILLER_40_449 VPWR VGND sg13g2_fill_1
XFILLER_40_438 VPWR VGND sg13g2_decap_8
XFILLER_32_25 VPWR VGND sg13g2_decap_8
XFILLER_21_663 VPWR VGND sg13g2_fill_2
XFILLER_20_151 VPWR VGND sg13g2_decap_8
XFILLER_0_567 VPWR VGND sg13g2_decap_8
XFILLER_48_527 VPWR VGND sg13g2_fill_1
XFILLER_43_210 VPWR VGND sg13g2_decap_8
XFILLER_28_284 VPWR VGND sg13g2_decap_8
XFILLER_43_287 VPWR VGND sg13g2_decap_8
XFILLER_8_612 VPWR VGND sg13g2_decap_4
XFILLER_11_151 VPWR VGND sg13g2_decap_8
XFILLER_7_133 VPWR VGND sg13g2_decap_8
XFILLER_3_361 VPWR VGND sg13g2_decap_8
X_2200_ _0971_ net157 state\[73\] VPWR VGND sg13g2_nand2_1
XFILLER_39_516 VPWR VGND sg13g2_decap_8
X_2131_ VGND VPWR _0629_ _0936_ _0422_ net73 sg13g2_a21oi_1
XFILLER_39_527 VPWR VGND sg13g2_fill_2
XFILLER_14_4 VPWR VGND sg13g2_decap_8
X_2062_ _0902_ net131 state\[4\] VPWR VGND sg13g2_nand2_1
XFILLER_47_560 VPWR VGND sg13g2_decap_4
XFILLER_19_284 VPWR VGND sg13g2_decap_8
XFILLER_34_221 VPWR VGND sg13g2_decap_8
XFILLER_34_298 VPWR VGND sg13g2_decap_8
X_1915_ net203 _0248_ _0793_ _0794_ VPWR VGND sg13g2_a21o_1
Xclkbuf_leaf_14_clk clknet_2_2__leaf_clk clknet_leaf_14_clk VPWR VGND sg13g2_buf_8
XFILLER_8_60 VPWR VGND sg13g2_decap_8
X_1846_ net229 VPWR _0742_ VGND state\[76\] net204 sg13g2_o21ai_1
X_1777_ VPWR VGND _0690_ net105 _0689_ _0209_ _0314_ net57 sg13g2_a221oi_1
X_2463__390 VPWR VGND net389 sg13g2_tiehi
X_2329_ net450 VGND VPWR _0275_ daisychain\[19\] clknet_leaf_1_clk sg13g2_dfrbpq_1
XFILLER_27_14 VPWR VGND sg13g2_decap_8
XFILLER_25_221 VPWR VGND sg13g2_decap_8
XFILLER_26_777 VPWR VGND sg13g2_decap_4
XFILLER_43_35 VPWR VGND sg13g2_decap_8
XFILLER_40_224 VPWR VGND sg13g2_decap_8
XFILLER_25_298 VPWR VGND sg13g2_decap_8
XFILLER_13_438 VPWR VGND sg13g2_decap_8
XFILLER_4_158 VPWR VGND sg13g2_decap_8
XFILLER_49_1012 VPWR VGND sg13g2_decap_8
XFILLER_49_1001 VPWR VGND sg13g2_fill_2
XFILLER_4_18 VPWR VGND sg13g2_decap_8
X_2442__474 VPWR VGND net473 sg13g2_tiehi
XFILLER_0_364 VPWR VGND sg13g2_decap_8
XFILLER_49_825 VPWR VGND sg13g2_fill_1
XFILLER_48_357 VPWR VGND sg13g2_decap_4
XFILLER_36_519 VPWR VGND sg13g2_decap_4
XFILLER_29_593 VPWR VGND sg13g2_decap_8
XFILLER_16_221 VPWR VGND sg13g2_decap_8
XFILLER_17_91 VPWR VGND sg13g2_decap_8
XFILLER_31_235 VPWR VGND sg13g2_decap_8
XFILLER_16_298 VPWR VGND sg13g2_decap_8
XFILLER_8_431 VPWR VGND sg13g2_decap_8
X_1700_ VGND VPWR net121 daisychain\[38\] _0633_ net28 sg13g2_a21oi_1
X_1631_ net184 _0170_ _0580_ _0581_ VPWR VGND sg13g2_a21o_1
X_1562_ net218 VPWR _0529_ VGND state\[5\] net184 sg13g2_o21ai_1
X_1493_ VPWR _0196_ daisychain\[46\] VGND sg13g2_inv_1
Xclkbuf_leaf_3_clk clknet_2_1__leaf_clk clknet_leaf_3_clk VPWR VGND sg13g2_buf_8
X_2114_ _0928_ net147 state\[30\] VPWR VGND sg13g2_nand2_1
XFILLER_39_357 VPWR VGND sg13g2_decap_8
X_2045_ VPWR VGND _0891_ net72 _0890_ _0156_ _0381_ net26 sg13g2_a221oi_1
Xfanout28 net34 net28 VPWR VGND sg13g2_buf_1
XFILLER_35_585 VPWR VGND sg13g2_decap_8
XFILLER_23_725 VPWR VGND sg13g2_fill_1
Xfanout39 net52 net39 VPWR VGND sg13g2_buf_1
XFILLER_23_769 VPWR VGND sg13g2_decap_8
XFILLER_22_235 VPWR VGND sg13g2_decap_8
X_1829_ VPWR VGND _0729_ net111 _0728_ _0224_ _0327_ net64 sg13g2_a221oi_1
X_2506__460 VPWR VGND net459 sg13g2_tiehi
XFILLER_2_607 VPWR VGND sg13g2_decap_8
X_2541__384 VPWR VGND net383 sg13g2_tiehi
X_2498__250 VPWR VGND net249 sg13g2_tiehi
XFILLER_38_35 VPWR VGND sg13g2_decap_8
XFILLER_46_806 VPWR VGND sg13g2_fill_2
XFILLER_18_508 VPWR VGND sg13g2_decap_8
XFILLER_26_585 VPWR VGND sg13g2_decap_8
XFILLER_13_235 VPWR VGND sg13g2_decap_8
XFILLER_9_228 VPWR VGND sg13g2_decap_8
XFILLER_5_445 VPWR VGND sg13g2_decap_4
XFILLER_5_489 VPWR VGND sg13g2_decap_8
XFILLER_1_651 VPWR VGND sg13g2_decap_4
XFILLER_0_161 VPWR VGND sg13g2_decap_8
X_2477__334 VPWR VGND net333 sg13g2_tiehi
XFILLER_49_655 VPWR VGND sg13g2_decap_4
XFILLER_48_154 VPWR VGND sg13g2_decap_8
X_2518__364 VPWR VGND net363 sg13g2_tiehi
XFILLER_44_371 VPWR VGND sg13g2_decap_8
XFILLER_32_533 VPWR VGND sg13g2_fill_1
X_1614_ net212 VPWR _0568_ VGND state\[18\] net172 sg13g2_o21ai_1
X_1545_ VPWR VGND _0514_ net82 _0516_ _0128_ _0256_ net36 sg13g2_a221oi_1
Xfanout229 net232 net229 VPWR VGND sg13g2_buf_1
Xfanout218 net222 net218 VPWR VGND sg13g2_buf_1
Xfanout207 net208 net207 VPWR VGND sg13g2_buf_1
X_1476_ VPWR _0215_ daisychain\[63\] VGND sg13g2_inv_1
X_2456__418 VPWR VGND net417 sg13g2_tiehi
XFILLER_28_806 VPWR VGND sg13g2_fill_2
XFILLER_39_154 VPWR VGND sg13g2_decap_8
X_2536__464 VPWR VGND net463 sg13g2_tiehi
X_2028_ VGND VPWR net117 daisychain\[120\] _0879_ net24 sg13g2_a21oi_1
X_2352__405 VPWR VGND net404 sg13g2_tiehi
XFILLER_42_308 VPWR VGND sg13g2_decap_8
XFILLER_35_393 VPWR VGND sg13g2_fill_2
XFILLER_10_249 VPWR VGND sg13g2_decap_8
XFILLER_40_14 VPWR VGND sg13g2_decap_8
XFILLER_2_404 VPWR VGND sg13g2_decap_8
XFILLER_46_1026 VPWR VGND sg13g2_fill_2
XFILLER_49_67 VPWR VGND sg13g2_decap_8
XFILLER_18_305 VPWR VGND sg13g2_decap_8
XANTENNA_101 VPWR VGND _0240_ sg13g2_antennanp
XANTENNA_112 VPWR VGND daisychain\[46\] sg13g2_antennanp
XANTENNA_123 VPWR VGND daisychain\[33\] sg13g2_antennanp
XANTENNA_134 VPWR VGND daisychain\[46\] sg13g2_antennanp
XFILLER_45_168 VPWR VGND sg13g2_decap_8
XFILLER_33_319 VPWR VGND sg13g2_decap_8
XFILLER_14_81 VPWR VGND sg13g2_decap_8
XFILLER_5_242 VPWR VGND sg13g2_decap_8
XFILLER_46_7 VPWR VGND sg13g2_decap_8
X_1330_ VPWR _0107_ state\[81\] VGND sg13g2_inv_1
Xinput7 ui_in[5] net7 VPWR VGND sg13g2_buf_1
XFILLER_49_452 VPWR VGND sg13g2_decap_8
XFILLER_37_614 VPWR VGND sg13g2_fill_1
XFILLER_37_603 VPWR VGND sg13g2_decap_8
XFILLER_36_168 VPWR VGND sg13g2_decap_8
XFILLER_24_319 VPWR VGND sg13g2_decap_8
XFILLER_17_393 VPWR VGND sg13g2_decap_8
XFILLER_20_569 VPWR VGND sg13g2_decap_4
XFILLER_10_39 VPWR VGND sg13g2_decap_8
X_1528_ VPWR _0150_ daisychain\[11\] VGND sg13g2_inv_1
X_1459_ VPWR _0234_ daisychain\[80\] VGND sg13g2_inv_1
XFILLER_35_14 VPWR VGND sg13g2_decap_8
XFILLER_28_669 VPWR VGND sg13g2_decap_8
XFILLER_27_168 VPWR VGND sg13g2_decap_8
XFILLER_42_105 VPWR VGND sg13g2_decap_8
XFILLER_15_319 VPWR VGND sg13g2_decap_8
XFILLER_24_864 VPWR VGND sg13g2_decap_4
XFILLER_23_396 VPWR VGND sg13g2_fill_1
XFILLER_7_507 VPWR VGND sg13g2_decap_8
XFILLER_3_768 VPWR VGND sg13g2_fill_1
XFILLER_3_757 VPWR VGND sg13g2_decap_8
XFILLER_2_256 VPWR VGND sg13g2_decap_8
XFILLER_47_901 VPWR VGND sg13g2_fill_1
XFILLER_47_956 VPWR VGND sg13g2_fill_1
XFILLER_18_102 VPWR VGND sg13g2_decap_8
XFILLER_46_455 VPWR VGND sg13g2_decap_8
XFILLER_33_116 VPWR VGND sg13g2_decap_8
XFILLER_18_179 VPWR VGND sg13g2_decap_8
XFILLER_27_691 VPWR VGND sg13g2_fill_1
XFILLER_42_683 VPWR VGND sg13g2_decap_8
XFILLER_41_182 VPWR VGND sg13g2_decap_8
XFILLER_14_396 VPWR VGND sg13g2_decap_8
X_2500_ net241 VGND VPWR _0446_ state\[62\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_2431_ net246 VGND VPWR _0377_ daisychain\[121\] clknet_leaf_18_clk sg13g2_dfrbpq_1
XFILLER_6_595 VPWR VGND sg13g2_decap_8
X_2362_ net384 VGND VPWR _0308_ daisychain\[52\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2293_ VGND VPWR _0872_ _1017_ _0503_ net83 sg13g2_a21oi_1
X_1313_ VPWR _0125_ state\[98\] VGND sg13g2_inv_1
XFILLER_2_95 VPWR VGND sg13g2_decap_8
XFILLER_24_116 VPWR VGND sg13g2_decap_8
XFILLER_33_650 VPWR VGND sg13g2_fill_2
XANTENNA_12 VPWR VGND _0195_ sg13g2_antennanp
XANTENNA_23 VPWR VGND daisychain\[31\] sg13g2_antennanp
XFILLER_32_193 VPWR VGND sg13g2_decap_8
XFILLER_20_333 VPWR VGND sg13g2_decap_8
XANTENNA_34 VPWR VGND _0150_ sg13g2_antennanp
XANTENNA_45 VPWR VGND _0192_ sg13g2_antennanp
XANTENNA_56 VPWR VGND _0241_ sg13g2_antennanp
XFILLER_21_867 VPWR VGND sg13g2_fill_1
XANTENNA_67 VPWR VGND daisychain\[33\] sg13g2_antennanp
XANTENNA_78 VPWR VGND daisychain\[81\] sg13g2_antennanp
XANTENNA_89 VPWR VGND _0183_ sg13g2_antennanp
XFILLER_0_716 VPWR VGND sg13g2_decap_4
XFILLER_46_35 VPWR VGND sg13g2_decap_8
XFILLER_16_606 VPWR VGND sg13g2_decap_4
XFILLER_44_937 VPWR VGND sg13g2_fill_1
XFILLER_28_499 VPWR VGND sg13g2_fill_1
XFILLER_16_628 VPWR VGND sg13g2_fill_1
XFILLER_16_617 VPWR VGND sg13g2_decap_8
XFILLER_15_116 VPWR VGND sg13g2_decap_8
XFILLER_43_436 VPWR VGND sg13g2_decap_8
XFILLER_11_333 VPWR VGND sg13g2_decap_8
XFILLER_7_315 VPWR VGND sg13g2_decap_8
XFILLER_23_193 VPWR VGND sg13g2_decap_8
XFILLER_11_377 VPWR VGND sg13g2_fill_1
XFILLER_11_60 VPWR VGND sg13g2_decap_8
XFILLER_3_543 VPWR VGND sg13g2_decap_8
XFILLER_3_598 VPWR VGND sg13g2_decap_8
XFILLER_19_411 VPWR VGND sg13g2_fill_2
XFILLER_19_400 VPWR VGND sg13g2_decap_8
XFILLER_47_797 VPWR VGND sg13g2_decap_4
XFILLER_46_252 VPWR VGND sg13g2_decap_8
XFILLER_19_488 VPWR VGND sg13g2_fill_1
X_1931_ net187 _0252_ _0805_ _0806_ VPWR VGND sg13g2_a21o_1
X_1862_ net230 VPWR _0754_ VGND state\[80\] net203 sg13g2_o21ai_1
XFILLER_30_653 VPWR VGND sg13g2_decap_8
XFILLER_14_193 VPWR VGND sg13g2_decap_8
X_1793_ VPWR VGND _0702_ net106 _0701_ _0214_ _0318_ net57 sg13g2_a221oi_1
X_2414_ net280 VGND VPWR _0360_ daisychain\[104\] clknet_leaf_5_clk sg13g2_dfrbpq_1
XFILLER_35_0 VPWR VGND sg13g2_decap_8
X_2345_ net418 VGND VPWR _0291_ daisychain\[35\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2276_ _1009_ net132 state\[111\] VPWR VGND sg13g2_nand2_1
XFILLER_37_252 VPWR VGND sg13g2_decap_8
XFILLER_20_130 VPWR VGND sg13g2_decap_8
XFILLER_0_546 VPWR VGND sg13g2_decap_8
X_2360__389 VPWR VGND net388 sg13g2_tiehi
XFILLER_28_263 VPWR VGND sg13g2_decap_8
XFILLER_16_403 VPWR VGND sg13g2_decap_8
XFILLER_43_266 VPWR VGND sg13g2_decap_8
XFILLER_11_130 VPWR VGND sg13g2_decap_8
XFILLER_7_112 VPWR VGND sg13g2_decap_8
XFILLER_8_657 VPWR VGND sg13g2_decap_8
XdacL state\[64\] _0088_ state\[65\] _0089_ state\[66\] _0090_ state\[67\] _0091_
+ state\[68\] _0092_ state\[69\] _0093_ state\[70\] _0095_ state\[71\] _0096_ state\[72\]
+ _0097_ digitalenL.g\[2\].u.OUTP digitalenL.g\[2\].u.OUTN state\[73\] _0098_ state\[74\]
+ _0099_ state\[75\] _0100_ state\[76\] _0101_ state\[77\] _0102_ state\[78\] _0103_
+ state\[79\] _0104_ state\[80\] _0106_ state\[81\] _0107_ state\[82\] _0108_ state\[83\]
+ _0109_ state\[84\] _0110_ state\[85\] _0111_ state\[86\] _0112_ state\[87\] _0113_
+ state\[88\] _0114_ state\[89\] _0115_ state\[90\] _0117_ state\[91\] _0118_ state\[92\]
+ _0119_ state\[93\] _0120_ state\[94\] _0121_ state\[95\] _0122_ state\[96\] _0123_
+ state\[97\] _0124_ state\[98\] _0125_ state\[99\] _0126_ state\[100\] _0001_ state\[101\]
+ _0002_ state\[102\] _0003_ state\[103\] _0004_ state\[104\] _0005_ state\[105\]
+ _0006_ state\[106\] _0007_ state\[107\] _0008_ state\[108\] _0009_ state\[109\]
+ _0010_ state\[110\] _0012_ state\[111\] _0013_ state\[112\] _0014_ state\[113\]
+ _0015_ state\[114\] _0016_ state\[115\] _0017_ state\[116\] _0018_ state\[117\]
+ _0019_ state\[118\] _0020_ state\[119\] _0021_ state\[120\] _0023_ state\[121\]
+ _0024_ state\[122\] _0025_ digitalenL.g\[3\].u.OUTP digitalenL.g\[3\].u.OUTN state\[123\]
+ _0026_ state\[124\] _0027_ state\[125\] _0028_ state\[126\] _0029_ state\[127\]
+ _0030_ state\[0\] _0000_ state\[1\] _0039_ state\[2\] _0050_ state\[3\] _0061_ state\[4\]
+ _0072_ state\[5\] _0083_ state\[6\] digitalenL.g\[0\].u.OUTP digitalenL.g\[0\].u.OUTN
+ _0094_ state\[7\] _0105_ state\[8\] _0116_ state\[9\] _0127_ state\[10\] _0011_
+ state\[11\] _0022_ state\[12\] _0031_ state\[13\] _0032_ state\[14\] _0033_ state\[15\]
+ _0034_ state\[16\] _0035_ state\[17\] _0036_ state\[18\] _0037_ state\[19\] _0038_
+ state\[20\] _0040_ state\[21\] _0041_ state\[22\] _0042_ state\[23\] _0043_ state\[24\]
+ _0044_ state\[25\] _0045_ state\[26\] _0046_ state\[27\] _0047_ state\[28\] _0048_
+ state\[29\] _0049_ state\[30\] _0051_ state\[31\] _0052_ state\[33\] _0054_ state\[32\]
+ _0053_ state\[34\] _0055_ state\[35\] _0056_ state\[36\] _0057_ state\[37\] _0058_
+ state\[38\] _0059_ state\[39\] _0060_ state\[40\] _0062_ state\[41\] _0063_ state\[42\]
+ _0064_ state\[43\] _0065_ state\[44\] _0066_ state\[45\] _0067_ state\[46\] _0068_
+ state\[47\] _0069_ state\[48\] _0070_ state\[49\] _0071_ state\[50\] _0073_ state\[51\]
+ _0074_ state\[52\] _0075_ state\[53\] _0076_ state\[54\] _0077_ state\[55\] _0078_
+ state\[56\] _0079_ state\[57\] _0080_ state\[58\] _0081_ state\[59\] _0082_ state\[60\]
+ _0084_ state\[61\] _0085_ state\[62\] _0086_ state\[63\] _0087_ digitalenL.g\[1\].u.OUTP
+ digitalenL.g\[1\].u.OUTN VGND VPWR dac128module
XFILLER_7_189 VPWR VGND sg13g2_decap_8
XFILLER_22_81 VPWR VGND sg13g2_decap_8
XFILLER_4_852 VPWR VGND sg13g2_decap_8
XFILLER_4_896 VPWR VGND sg13g2_decap_8
XFILLER_3_340 VPWR VGND sg13g2_decap_8
X_2406__297 VPWR VGND net296 sg13g2_tiehi
X_2130_ _0936_ net120 state\[38\] VPWR VGND sg13g2_nand2_1
X_2061_ VGND VPWR _0524_ _0901_ _0387_ net84 sg13g2_a21oi_1
XFILLER_47_583 VPWR VGND sg13g2_decap_8
XFILLER_34_200 VPWR VGND sg13g2_decap_8
XFILLER_19_263 VPWR VGND sg13g2_decap_8
XFILLER_23_907 VPWR VGND sg13g2_fill_2
XFILLER_34_277 VPWR VGND sg13g2_decap_8
X_1914_ net229 VPWR _0793_ VGND state\[93\] net201 sg13g2_o21ai_1
X_1845_ VPWR VGND _0741_ net110 _0740_ _0228_ _0331_ net63 sg13g2_a221oi_1
X_1776_ VGND VPWR net158 daisychain\[57\] _0690_ net64 sg13g2_a21oi_1
X_2328_ net452 VGND VPWR _0274_ daisychain\[18\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2259_ VGND VPWR _0821_ _1000_ _0486_ net95 sg13g2_a21oi_1
XFILLER_25_200 VPWR VGND sg13g2_decap_8
X_2470__362 VPWR VGND net361 sg13g2_tiehi
XFILLER_43_14 VPWR VGND sg13g2_decap_8
XFILLER_26_789 VPWR VGND sg13g2_fill_1
XFILLER_40_203 VPWR VGND sg13g2_decap_8
XFILLER_25_277 VPWR VGND sg13g2_decap_8
XFILLER_13_417 VPWR VGND sg13g2_decap_8
XFILLER_4_137 VPWR VGND sg13g2_decap_8
XFILLER_0_343 VPWR VGND sg13g2_decap_8
XFILLER_49_837 VPWR VGND sg13g2_fill_2
XFILLER_48_336 VPWR VGND sg13g2_decap_8
XFILLER_29_561 VPWR VGND sg13g2_decap_4
XFILLER_16_200 VPWR VGND sg13g2_decap_8
XFILLER_17_70 VPWR VGND sg13g2_decap_8
XFILLER_31_214 VPWR VGND sg13g2_decap_8
XFILLER_16_277 VPWR VGND sg13g2_decap_8
XFILLER_8_410 VPWR VGND sg13g2_decap_8
XFILLER_12_494 VPWR VGND sg13g2_decap_8
X_1630_ net212 VPWR _0580_ VGND state\[22\] net183 sg13g2_o21ai_1
XFILLER_8_487 VPWR VGND sg13g2_decap_8
X_1561_ VPWR VGND _0528_ net84 _0527_ _0200_ _0260_ net38 sg13g2_a221oi_1
X_1492_ VPWR _0197_ daisychain\[47\] VGND sg13g2_inv_1
X_2113_ VGND VPWR _0602_ _0927_ _0413_ net100 sg13g2_a21oi_1
XFILLER_39_336 VPWR VGND sg13g2_decap_8
X_2044_ VGND VPWR net116 daisychain\[124\] _0891_ net26 sg13g2_a21oi_1
Xfanout29 net34 net29 VPWR VGND sg13g2_buf_1
XFILLER_23_737 VPWR VGND sg13g2_fill_1
XFILLER_22_214 VPWR VGND sg13g2_decap_8
XFILLER_13_39 VPWR VGND sg13g2_decap_8
XFILLER_30_291 VPWR VGND sg13g2_decap_8
X_1828_ VGND VPWR net158 daisychain\[70\] _0729_ net64 sg13g2_a21oi_1
X_1759_ net199 _0205_ _0676_ _0677_ VPWR VGND sg13g2_a21o_1
XFILLER_38_14 VPWR VGND sg13g2_decap_8
X_2359__391 VPWR VGND net390 sg13g2_tiehi
XFILLER_14_715 VPWR VGND sg13g2_decap_8
XFILLER_13_214 VPWR VGND sg13g2_decap_8
XFILLER_9_207 VPWR VGND sg13g2_decap_8
XFILLER_41_589 VPWR VGND sg13g2_decap_4
XFILLER_21_291 VPWR VGND sg13g2_decap_8
XFILLER_5_424 VPWR VGND sg13g2_decap_8
XFILLER_5_468 VPWR VGND sg13g2_decap_8
XFILLER_1_630 VPWR VGND sg13g2_decap_8
XFILLER_0_140 VPWR VGND sg13g2_decap_8
XFILLER_48_133 VPWR VGND sg13g2_decap_8
XFILLER_23_1027 VPWR VGND sg13g2_fill_2
XFILLER_23_1016 VPWR VGND sg13g2_decap_8
XFILLER_44_350 VPWR VGND sg13g2_decap_8
XFILLER_17_542 VPWR VGND sg13g2_decap_8
XFILLER_32_523 VPWR VGND sg13g2_fill_2
X_2484__306 VPWR VGND net305 sg13g2_tiehi
XFILLER_12_291 VPWR VGND sg13g2_decap_8
XFILLER_8_284 VPWR VGND sg13g2_decap_8
X_1613_ VPWR VGND _0567_ net70 _0566_ _0164_ _0273_ net24 sg13g2_a221oi_1
X_1544_ VGND VPWR net129 net2 _0516_ net36 sg13g2_a21oi_1
Xfanout219 net222 net219 VPWR VGND sg13g2_buf_1
Xfanout208 net5 net208 VPWR VGND sg13g2_buf_1
XFILLER_5_95 VPWR VGND sg13g2_decap_8
X_1475_ VPWR _0216_ daisychain\[64\] VGND sg13g2_inv_1
XFILLER_39_133 VPWR VGND sg13g2_decap_8
X_2027_ net164 _0152_ _0877_ _0878_ VPWR VGND sg13g2_a21o_1
XFILLER_35_350 VPWR VGND sg13g2_decap_8
XFILLER_23_512 VPWR VGND sg13g2_decap_8
XFILLER_11_718 VPWR VGND sg13g2_decap_4
XFILLER_10_228 VPWR VGND sg13g2_decap_8
XFILLER_49_46 VPWR VGND sg13g2_decap_8
XANTENNA_102 VPWR VGND _0249_ sg13g2_antennanp
XANTENNA_113 VPWR VGND daisychain\[92\] sg13g2_antennanp
XANTENNA_124 VPWR VGND daisychain\[33\] sg13g2_antennanp
XFILLER_45_147 VPWR VGND sg13g2_decap_8
XANTENNA_135 VPWR VGND daisychain\[46\] sg13g2_antennanp
XFILLER_26_372 VPWR VGND sg13g2_fill_2
XFILLER_26_361 VPWR VGND sg13g2_decap_8
XFILLER_41_364 VPWR VGND sg13g2_fill_2
XFILLER_14_60 VPWR VGND sg13g2_decap_8
XFILLER_5_221 VPWR VGND sg13g2_decap_8
XFILLER_5_298 VPWR VGND sg13g2_decap_8
XFILLER_30_81 VPWR VGND sg13g2_decap_8
XFILLER_39_7 VPWR VGND sg13g2_decap_8
XFILLER_2_972 VPWR VGND sg13g2_decap_8
XFILLER_49_431 VPWR VGND sg13g2_decap_8
XFILLER_49_497 VPWR VGND sg13g2_fill_2
XFILLER_37_626 VPWR VGND sg13g2_fill_1
XdigitalenL.g\[1\].u.inv1 VPWR digitalenL.g\[1\].u.OUTN net6 VGND sg13g2_inv_1
XFILLER_36_147 VPWR VGND sg13g2_decap_8
XFILLER_17_372 VPWR VGND sg13g2_decap_8
XFILLER_17_350 VPWR VGND sg13g2_decap_8
XFILLER_32_375 VPWR VGND sg13g2_decap_8
XFILLER_9_571 VPWR VGND sg13g2_fill_2
XFILLER_10_18 VPWR VGND sg13g2_decap_8
X_1527_ VPWR _0159_ daisychain\[12\] VGND sg13g2_inv_1
X_1458_ VPWR _0235_ daisychain\[81\] VGND sg13g2_inv_1
X_1389_ VPWR _0042_ state\[22\] VGND sg13g2_inv_1
XFILLER_28_637 VPWR VGND sg13g2_fill_2
XFILLER_43_607 VPWR VGND sg13g2_fill_2
XFILLER_27_147 VPWR VGND sg13g2_decap_8
XFILLER_24_887 VPWR VGND sg13g2_fill_2
XFILLER_23_375 VPWR VGND sg13g2_decap_8
XFILLER_11_526 VPWR VGND sg13g2_decap_8
XFILLER_4_4 VPWR VGND sg13g2_decap_8
XFILLER_2_235 VPWR VGND sg13g2_decap_8
XFILLER_46_434 VPWR VGND sg13g2_decap_8
XFILLER_18_158 VPWR VGND sg13g2_decap_8
X_2370__369 VPWR VGND net368 sg13g2_tiehi
XFILLER_25_81 VPWR VGND sg13g2_decap_8
XFILLER_41_161 VPWR VGND sg13g2_decap_8
XFILLER_14_375 VPWR VGND sg13g2_decap_8
XFILLER_41_91 VPWR VGND sg13g2_decap_8
X_2430_ net248 VGND VPWR _0376_ daisychain\[120\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2361_ net386 VGND VPWR _0307_ daisychain\[51\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2292_ _1017_ net130 state\[119\] VPWR VGND sg13g2_nand2_1
X_1312_ VPWR _0126_ state\[99\] VGND sg13g2_inv_1
XFILLER_2_74 VPWR VGND sg13g2_decap_8
XFILLER_25_629 VPWR VGND sg13g2_fill_1
X_2416__277 VPWR VGND net276 sg13g2_tiehi
XANTENNA_13 VPWR VGND _0235_ sg13g2_antennanp
XFILLER_32_172 VPWR VGND sg13g2_decap_8
XFILLER_21_846 VPWR VGND sg13g2_fill_1
XFILLER_20_312 VPWR VGND sg13g2_decap_8
XANTENNA_24 VPWR VGND daisychain\[32\] sg13g2_antennanp
XANTENNA_35 VPWR VGND _0150_ sg13g2_antennanp
XANTENNA_46 VPWR VGND _0194_ sg13g2_antennanp
XANTENNA_57 VPWR VGND _0241_ sg13g2_antennanp
XANTENNA_68 VPWR VGND daisychain\[33\] sg13g2_antennanp
XANTENNA_79 VPWR VGND daisychain\[81\] sg13g2_antennanp
XFILLER_21_39 VPWR VGND sg13g2_decap_8
X_2559_ net455 VGND VPWR _0505_ state\[121\] clknet_leaf_18_clk sg13g2_dfrbpq_1
XFILLER_46_14 VPWR VGND sg13g2_decap_8
XFILLER_28_423 VPWR VGND sg13g2_decap_8
XFILLER_44_905 VPWR VGND sg13g2_fill_2
XFILLER_30_109 VPWR VGND sg13g2_decap_8
XFILLER_24_662 VPWR VGND sg13g2_decap_8
XFILLER_11_312 VPWR VGND sg13g2_decap_8
XFILLER_23_172 VPWR VGND sg13g2_decap_8
XFILLER_11_389 VPWR VGND sg13g2_decap_8
X_2445__462 VPWR VGND net461 sg13g2_tiehi
XFILLER_3_522 VPWR VGND sg13g2_decap_8
XFILLER_46_231 VPWR VGND sg13g2_decap_8
XFILLER_36_91 VPWR VGND sg13g2_decap_8
XFILLER_21_109 VPWR VGND sg13g2_decap_8
XFILLER_15_651 VPWR VGND sg13g2_decap_4
X_1930_ net220 VPWR _0805_ VGND state\[97\] net188 sg13g2_o21ai_1
XFILLER_15_684 VPWR VGND sg13g2_fill_1
XFILLER_14_172 VPWR VGND sg13g2_decap_8
X_1861_ VPWR VGND _0753_ net109 _0752_ _0232_ _0335_ net62 sg13g2_a221oi_1
X_1792_ VGND VPWR net153 daisychain\[61\] _0702_ net57 sg13g2_a21oi_1
XFILLER_6_382 VPWR VGND sg13g2_decap_8
X_2413_ net282 VGND VPWR _0359_ daisychain\[103\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2344_ net420 VGND VPWR _0290_ daisychain\[34\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2275_ VGND VPWR _0845_ _1008_ _0494_ net89 sg13g2_a21oi_1
XFILLER_38_721 VPWR VGND sg13g2_fill_2
XFILLER_37_231 VPWR VGND sg13g2_decap_8
XFILLER_16_39 VPWR VGND sg13g2_decap_8
XFILLER_12_109 VPWR VGND sg13g2_decap_8
X_2318__473 VPWR VGND net472 sg13g2_tiehi
XFILLER_21_665 VPWR VGND sg13g2_fill_1
XFILLER_20_186 VPWR VGND sg13g2_decap_8
XFILLER_4_319 VPWR VGND sg13g2_decap_8
XFILLER_0_525 VPWR VGND sg13g2_decap_8
XFILLER_28_242 VPWR VGND sg13g2_decap_8
XFILLER_43_245 VPWR VGND sg13g2_decap_8
XFILLER_8_636 VPWR VGND sg13g2_fill_1
XFILLER_11_186 VPWR VGND sg13g2_decap_8
X_2369__371 VPWR VGND net370 sg13g2_tiehi
XFILLER_22_60 VPWR VGND sg13g2_decap_8
XFILLER_7_168 VPWR VGND sg13g2_decap_8
XFILLER_3_396 VPWR VGND sg13g2_decap_8
X_2060_ _0901_ net131 state\[3\] VPWR VGND sg13g2_nand2_1
XFILLER_19_242 VPWR VGND sg13g2_decap_8
XFILLER_34_256 VPWR VGND sg13g2_decap_8
XFILLER_23_919 VPWR VGND sg13g2_fill_2
X_1913_ VPWR VGND _0792_ net108 _0791_ _0247_ _0348_ net61 sg13g2_a221oi_1
X_1844_ VGND VPWR net157 daisychain\[74\] _0741_ net63 sg13g2_a21oi_1
X_1775_ net197 _0209_ _0688_ _0689_ VPWR VGND sg13g2_a21o_1
XFILLER_8_95 VPWR VGND sg13g2_decap_8
X_2459__406 VPWR VGND net405 sg13g2_tiehi
X_2500__242 VPWR VGND net241 sg13g2_tiehi
X_2327_ net454 VGND VPWR _0273_ daisychain\[17\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2258_ _1000_ net143 state\[102\] VPWR VGND sg13g2_nand2_1
XFILLER_27_49 VPWR VGND sg13g2_decap_8
X_2189_ VGND VPWR _0716_ _0965_ _0451_ net113 sg13g2_a21oi_1
XFILLER_38_584 VPWR VGND sg13g2_decap_8
XFILLER_25_256 VPWR VGND sg13g2_decap_8
XFILLER_40_259 VPWR VGND sg13g2_decap_8
XFILLER_5_617 VPWR VGND sg13g2_decap_8
XFILLER_4_116 VPWR VGND sg13g2_decap_8
XFILLER_0_322 VPWR VGND sg13g2_decap_8
XFILLER_49_816 VPWR VGND sg13g2_fill_2
XFILLER_49_805 VPWR VGND sg13g2_decap_4
XFILLER_48_315 VPWR VGND sg13g2_decap_8
XFILLER_0_399 VPWR VGND sg13g2_decap_8
XFILLER_16_256 VPWR VGND sg13g2_decap_8
XFILLER_12_473 VPWR VGND sg13g2_decap_8
XFILLER_33_81 VPWR VGND sg13g2_decap_8
XFILLER_8_466 VPWR VGND sg13g2_decap_8
X_1560_ VGND VPWR net131 daisychain\[3\] _0528_ net38 sg13g2_a21oi_1
X_1491_ VPWR _0198_ daisychain\[48\] VGND sg13g2_inv_1
XFILLER_3_193 VPWR VGND sg13g2_decap_8
XFILLER_39_315 VPWR VGND sg13g2_decap_8
X_2112_ _0927_ net147 state\[29\] VPWR VGND sg13g2_nand2_1
X_2043_ net166 _0156_ _0889_ _0890_ VPWR VGND sg13g2_a21o_1
XFILLER_47_392 VPWR VGND sg13g2_decap_8
X_2530__268 VPWR VGND net267 sg13g2_tiehi
XFILLER_13_18 VPWR VGND sg13g2_decap_8
XFILLER_30_270 VPWR VGND sg13g2_decap_8
X_1827_ net207 _0224_ _0727_ _0728_ VPWR VGND sg13g2_a21o_1
X_1758_ net227 VPWR _0676_ VGND state\[54\] net199 sg13g2_o21ai_1
X_1689_ VPWR VGND _0624_ net73 _0623_ _0185_ _0292_ net27 sg13g2_a221oi_1
XFILLER_1_119 VPWR VGND sg13g2_decap_8
XFILLER_45_329 VPWR VGND sg13g2_decap_8
XFILLER_26_510 VPWR VGND sg13g2_decap_8
XFILLER_26_554 VPWR VGND sg13g2_fill_2
XFILLER_21_270 VPWR VGND sg13g2_decap_8
XFILLER_5_403 VPWR VGND sg13g2_decap_8
XFILLER_49_613 VPWR VGND sg13g2_decap_8
XFILLER_0_196 VPWR VGND sg13g2_decap_8
XFILLER_48_112 VPWR VGND sg13g2_decap_8
XFILLER_49_679 VPWR VGND sg13g2_decap_8
XFILLER_48_189 VPWR VGND sg13g2_decap_8
XFILLER_36_329 VPWR VGND sg13g2_decap_8
XFILLER_28_81 VPWR VGND sg13g2_decap_8
XFILLER_17_587 VPWR VGND sg13g2_fill_1
XFILLER_44_91 VPWR VGND sg13g2_decap_8
XFILLER_12_270 VPWR VGND sg13g2_decap_8
XFILLER_8_263 VPWR VGND sg13g2_decap_8
X_1612_ VGND VPWR net117 daisychain\[16\] _0567_ net24 sg13g2_a21oi_1
X_2380__349 VPWR VGND net348 sg13g2_tiehi
X_1543_ net215 net3 _0515_ VPWR VGND sg13g2_nor2_1
Xfanout209 net210 net209 VPWR VGND sg13g2_buf_1
X_1474_ VPWR _0217_ daisychain\[65\] VGND sg13g2_inv_1
XFILLER_5_74 VPWR VGND sg13g2_decap_8
XFILLER_39_112 VPWR VGND sg13g2_decap_8
XFILLER_39_189 VPWR VGND sg13g2_decap_8
XFILLER_27_329 VPWR VGND sg13g2_decap_8
X_2026_ net209 VPWR _0877_ VGND state\[121\] net164 sg13g2_o21ai_1
XFILLER_35_395 VPWR VGND sg13g2_fill_1
XFILLER_24_39 VPWR VGND sg13g2_decap_8
XFILLER_10_207 VPWR VGND sg13g2_decap_8
XFILLER_40_49 VPWR VGND sg13g2_decap_8
X_2426__257 VPWR VGND net256 sg13g2_tiehi
XFILLER_46_1006 VPWR VGND sg13g2_fill_2
XFILLER_2_439 VPWR VGND sg13g2_decap_8
XFILLER_49_25 VPWR VGND sg13g2_decap_8
XFILLER_46_1028 VPWR VGND sg13g2_fill_1
XFILLER_45_126 VPWR VGND sg13g2_decap_8
XFILLER_39_690 VPWR VGND sg13g2_decap_4
XANTENNA_103 VPWR VGND _0249_ sg13g2_antennanp
XANTENNA_114 VPWR VGND _0132_ sg13g2_antennanp
XANTENNA_125 VPWR VGND daisychain\[34\] sg13g2_antennanp
XFILLER_27_841 VPWR VGND sg13g2_fill_2
XFILLER_26_340 VPWR VGND sg13g2_decap_8
XANTENNA_136 VPWR VGND daisychain\[90\] sg13g2_antennanp
XFILLER_14_513 VPWR VGND sg13g2_decap_8
XFILLER_41_343 VPWR VGND sg13g2_decap_8
XFILLER_5_200 VPWR VGND sg13g2_decap_8
XFILLER_5_277 VPWR VGND sg13g2_decap_8
XFILLER_30_60 VPWR VGND sg13g2_decap_8
XFILLER_2_951 VPWR VGND sg13g2_decap_8
XFILLER_49_410 VPWR VGND sg13g2_decap_8
XFILLER_1_483 VPWR VGND sg13g2_decap_8
XFILLER_39_91 VPWR VGND sg13g2_decap_8
XFILLER_36_126 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[1\].u.inv2 VPWR digitalenL.g\[1\].u.OUTP digitalenL.g\[1\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_45_693 VPWR VGND sg13g2_decap_8
XFILLER_32_354 VPWR VGND sg13g2_decap_8
X_1526_ VPWR _0160_ daisychain\[13\] VGND sg13g2_inv_1
X_1457_ VPWR _0236_ daisychain\[82\] VGND sg13g2_inv_1
X_1388_ VPWR _0043_ state\[23\] VGND sg13g2_inv_1
XFILLER_19_39 VPWR VGND sg13g2_decap_8
XFILLER_27_126 VPWR VGND sg13g2_decap_8
XFILLER_36_660 VPWR VGND sg13g2_decap_8
XFILLER_35_49 VPWR VGND sg13g2_decap_8
XFILLER_24_811 VPWR VGND sg13g2_fill_1
X_2009_ VPWR VGND _0864_ net89 _0863_ _0146_ _0372_ net43 sg13g2_a221oi_1
XFILLER_23_354 VPWR VGND sg13g2_decap_8
X_2328__453 VPWR VGND net452 sg13g2_tiehi
XFILLER_3_737 VPWR VGND sg13g2_fill_1
XFILLER_2_214 VPWR VGND sg13g2_decap_8
XFILLER_46_413 VPWR VGND sg13g2_decap_8
XFILLER_18_137 VPWR VGND sg13g2_decap_8
XFILLER_41_140 VPWR VGND sg13g2_decap_8
XFILLER_25_60 VPWR VGND sg13g2_decap_8
XFILLER_14_354 VPWR VGND sg13g2_decap_8
XFILLER_6_531 VPWR VGND sg13g2_decap_8
XFILLER_41_70 VPWR VGND sg13g2_decap_8
XFILLER_6_586 VPWR VGND sg13g2_fill_1
XFILLER_6_575 VPWR VGND sg13g2_decap_8
X_2360_ net388 VGND VPWR _0306_ daisychain\[50\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2291_ VGND VPWR _0869_ _1016_ _0502_ net89 sg13g2_a21oi_1
X_1311_ VPWR _0001_ state\[100\] VGND sg13g2_inv_1
X_2379__351 VPWR VGND net350 sg13g2_tiehi
XFILLER_2_53 VPWR VGND sg13g2_decap_8
XFILLER_1_280 VPWR VGND sg13g2_decap_8
XFILLER_49_284 VPWR VGND sg13g2_decap_8
XFILLER_37_479 VPWR VGND sg13g2_decap_4
XFILLER_33_674 VPWR VGND sg13g2_fill_1
XFILLER_21_803 VPWR VGND sg13g2_fill_1
XANTENNA_14 VPWR VGND _0255_ sg13g2_antennanp
XFILLER_33_685 VPWR VGND sg13g2_decap_8
XFILLER_32_151 VPWR VGND sg13g2_decap_8
XANTENNA_25 VPWR VGND daisychain\[50\] sg13g2_antennanp
XANTENNA_36 VPWR VGND _0159_ sg13g2_antennanp
XANTENNA_47 VPWR VGND _0194_ sg13g2_antennanp
XFILLER_21_858 VPWR VGND sg13g2_fill_1
XANTENNA_58 VPWR VGND _0242_ sg13g2_antennanp
XANTENNA_69 VPWR VGND daisychain\[38\] sg13g2_antennanp
XFILLER_21_18 VPWR VGND sg13g2_decap_8
XFILLER_20_368 VPWR VGND sg13g2_decap_8
X_2558_ net247 VGND VPWR _0504_ state\[120\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2489_ net285 VGND VPWR _0435_ state\[51\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1509_ VPWR _0179_ daisychain\[30\] VGND sg13g2_inv_1
X_2473__350 VPWR VGND net349 sg13g2_tiehi
XFILLER_43_405 VPWR VGND sg13g2_decap_8
XFILLER_24_630 VPWR VGND sg13g2_decap_4
XFILLER_23_151 VPWR VGND sg13g2_decap_8
XFILLER_11_368 VPWR VGND sg13g2_decap_8
XFILLER_3_501 VPWR VGND sg13g2_decap_8
XFILLER_11_95 VPWR VGND sg13g2_decap_8
X_2521__340 VPWR VGND net339 sg13g2_tiehi
XFILLER_3_578 VPWR VGND sg13g2_decap_8
XFILLER_4_1025 VPWR VGND sg13g2_decap_4
XFILLER_4_1003 VPWR VGND sg13g2_fill_2
XFILLER_47_711 VPWR VGND sg13g2_decap_8
XFILLER_47_744 VPWR VGND sg13g2_decap_8
XFILLER_46_210 VPWR VGND sg13g2_decap_8
XFILLER_19_479 VPWR VGND sg13g2_decap_4
X_2452__434 VPWR VGND net433 sg13g2_tiehi
XFILLER_46_287 VPWR VGND sg13g2_decap_8
XFILLER_36_70 VPWR VGND sg13g2_decap_8
XFILLER_30_622 VPWR VGND sg13g2_decap_4
XFILLER_14_151 VPWR VGND sg13g2_decap_8
X_1860_ VGND VPWR net156 daisychain\[78\] _0753_ net62 sg13g2_a21oi_1
X_1791_ net198 _0214_ _0700_ _0701_ VPWR VGND sg13g2_a21o_1
XFILLER_6_361 VPWR VGND sg13g2_decap_8
X_2412_ net284 VGND VPWR _0358_ daisychain\[102\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2343_ net422 VGND VPWR _0289_ daisychain\[33\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2274_ _1008_ net136 state\[110\] VPWR VGND sg13g2_nand2_1
XFILLER_37_210 VPWR VGND sg13g2_decap_8
XFILLER_26_928 VPWR VGND sg13g2_fill_2
XFILLER_25_405 VPWR VGND sg13g2_fill_2
X_2533__244 VPWR VGND net243 sg13g2_tiehi
XFILLER_37_287 VPWR VGND sg13g2_decap_8
XFILLER_16_18 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_17_clk clknet_2_0__leaf_clk clknet_leaf_17_clk VPWR VGND sg13g2_buf_8
XFILLER_40_408 VPWR VGND sg13g2_decap_8
XFILLER_32_39 VPWR VGND sg13g2_decap_8
XFILLER_20_165 VPWR VGND sg13g2_decap_8
X_1989_ VPWR VGND _0849_ net87 _0848_ _0141_ _0367_ net40 sg13g2_a221oi_1
XFILLER_0_504 VPWR VGND sg13g2_decap_8
XFILLER_29_711 VPWR VGND sg13g2_decap_4
XFILLER_29_755 VPWR VGND sg13g2_decap_8
XFILLER_28_221 VPWR VGND sg13g2_decap_8
XFILLER_43_224 VPWR VGND sg13g2_decap_8
XFILLER_28_298 VPWR VGND sg13g2_decap_8
XFILLER_24_482 VPWR VGND sg13g2_decap_8
XFILLER_11_165 VPWR VGND sg13g2_decap_8
XFILLER_8_626 VPWR VGND sg13g2_fill_1
XFILLER_7_147 VPWR VGND sg13g2_decap_8
XFILLER_4_832 VPWR VGND sg13g2_fill_1
XFILLER_3_375 VPWR VGND sg13g2_decap_8
XFILLER_19_221 VPWR VGND sg13g2_decap_8
XFILLER_47_91 VPWR VGND sg13g2_decap_8
XFILLER_19_298 VPWR VGND sg13g2_decap_8
XFILLER_34_235 VPWR VGND sg13g2_decap_8
X_1912_ VGND VPWR net155 daisychain\[91\] _0792_ net61 sg13g2_a21oi_1
X_1843_ net202 _0228_ _0739_ _0740_ VPWR VGND sg13g2_a21o_1
XFILLER_8_74 VPWR VGND sg13g2_decap_8
X_1774_ net227 VPWR _0688_ VGND state\[58\] net197 sg13g2_o21ai_1
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk clknet_leaf_6_clk VPWR VGND sg13g2_buf_8
XFILLER_40_0 VPWR VGND sg13g2_decap_8
X_2326_ net456 VGND VPWR _0272_ daisychain\[16\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2257_ VGND VPWR _0818_ _0999_ _0485_ net92 sg13g2_a21oi_1
XFILLER_27_28 VPWR VGND sg13g2_decap_8
X_2188_ _0965_ net161 state\[67\] VPWR VGND sg13g2_nand2_1
X_2390__329 VPWR VGND net328 sg13g2_tiehi
XFILLER_25_235 VPWR VGND sg13g2_decap_8
XFILLER_43_49 VPWR VGND sg13g2_decap_8
XFILLER_40_238 VPWR VGND sg13g2_decap_8
XFILLER_22_997 VPWR VGND sg13g2_fill_2
XFILLER_22_986 VPWR VGND sg13g2_decap_8
XFILLER_49_1026 VPWR VGND sg13g2_fill_2
XFILLER_0_301 VPWR VGND sg13g2_decap_8
XFILLER_0_378 VPWR VGND sg13g2_decap_8
X_2436__237 VPWR VGND net236 sg13g2_tiehi
XFILLER_44_511 VPWR VGND sg13g2_decap_8
XFILLER_16_235 VPWR VGND sg13g2_decap_8
XFILLER_31_249 VPWR VGND sg13g2_decap_8
XFILLER_12_452 VPWR VGND sg13g2_decap_8
XFILLER_33_60 VPWR VGND sg13g2_decap_8
XFILLER_8_445 VPWR VGND sg13g2_decap_8
X_1490_ VPWR _0199_ daisychain\[49\] VGND sg13g2_inv_1
XFILLER_3_172 VPWR VGND sg13g2_decap_8
XFILLER_12_4 VPWR VGND sg13g2_decap_8
X_2111_ VGND VPWR _0599_ _0926_ _0412_ net73 sg13g2_a21oi_1
X_2042_ net209 VPWR _0889_ VGND state\[125\] net166 sg13g2_o21ai_1
XFILLER_47_371 VPWR VGND sg13g2_decap_8
XFILLER_22_249 VPWR VGND sg13g2_decap_8
X_1826_ net231 VPWR _0727_ VGND state\[71\] net207 sg13g2_o21ai_1
X_1757_ VPWR VGND _0675_ net103 _0674_ _0204_ _0309_ net54 sg13g2_a221oi_1
X_1688_ VGND VPWR net120 daisychain\[35\] _0624_ net27 sg13g2_a21oi_1
X_2309_ VGND VPWR _0896_ _1025_ _0511_ net72 sg13g2_a21oi_1
XFILLER_38_49 VPWR VGND sg13g2_decap_8
XFILLER_45_308 VPWR VGND sg13g2_decap_8
XFILLER_38_371 VPWR VGND sg13g2_fill_2
XFILLER_38_393 VPWR VGND sg13g2_fill_2
XFILLER_41_514 VPWR VGND sg13g2_fill_2
XFILLER_26_599 VPWR VGND sg13g2_fill_2
XFILLER_13_249 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_490 VPWR VGND uio_oe[1] sg13g2_tiehi
XFILLER_41_569 VPWR VGND sg13g2_decap_8
XFILLER_0_175 VPWR VGND sg13g2_decap_8
XFILLER_48_168 VPWR VGND sg13g2_decap_8
XFILLER_36_308 VPWR VGND sg13g2_decap_8
X_2338__433 VPWR VGND net432 sg13g2_tiehi
XFILLER_28_60 VPWR VGND sg13g2_decap_8
XFILLER_29_393 VPWR VGND sg13g2_decap_8
XFILLER_44_70 VPWR VGND sg13g2_decap_8
XFILLER_44_385 VPWR VGND sg13g2_decap_8
XFILLER_32_569 VPWR VGND sg13g2_fill_2
XFILLER_8_242 VPWR VGND sg13g2_decap_8
X_1611_ net164 _0164_ _0565_ _0566_ VPWR VGND sg13g2_a21o_1
XFILLER_5_960 VPWR VGND sg13g2_fill_1
X_1542_ net176 _0128_ _0513_ _0514_ VPWR VGND sg13g2_a21o_1
XFILLER_5_53 VPWR VGND sg13g2_decap_8
X_1473_ VPWR _0218_ daisychain\[66\] VGND sg13g2_inv_1
XFILLER_39_168 VPWR VGND sg13g2_decap_8
XFILLER_27_308 VPWR VGND sg13g2_decap_8
X_2025_ VPWR VGND _0876_ net83 _0875_ _0151_ _0376_ net37 sg13g2_a221oi_1
XFILLER_24_18 VPWR VGND sg13g2_decap_8
X_2389__331 VPWR VGND net330 sg13g2_tiehi
XFILLER_40_28 VPWR VGND sg13g2_decap_8
X_1809_ VPWR VGND _0714_ net112 _0713_ _0218_ _0322_ net67 sg13g2_a221oi_1
XFILLER_3_919 VPWR VGND sg13g2_fill_2
XFILLER_2_418 VPWR VGND sg13g2_decap_8
XFILLER_45_105 VPWR VGND sg13g2_decap_8
XFILLER_18_319 VPWR VGND sg13g2_decap_8
XANTENNA_104 VPWR VGND daisychain\[16\] sg13g2_antennanp
XANTENNA_115 VPWR VGND _0168_ sg13g2_antennanp
XANTENNA_126 VPWR VGND daisychain\[34\] sg13g2_antennanp
XANTENNA_137 VPWR VGND daisychain\[90\] sg13g2_antennanp
XFILLER_41_322 VPWR VGND sg13g2_decap_8
XFILLER_26_396 VPWR VGND sg13g2_decap_4
XFILLER_41_366 VPWR VGND sg13g2_fill_1
XFILLER_14_95 VPWR VGND sg13g2_decap_8
X_2448__450 VPWR VGND net449 sg13g2_tiehi
XFILLER_5_256 VPWR VGND sg13g2_decap_8
XFILLER_2_941 VPWR VGND sg13g2_fill_1
XFILLER_2_985 VPWR VGND sg13g2_fill_1
XFILLER_1_462 VPWR VGND sg13g2_decap_8
X_2559__456 VPWR VGND net455 sg13g2_tiehi
XFILLER_49_466 VPWR VGND sg13g2_decap_8
XFILLER_39_70 VPWR VGND sg13g2_decap_8
XFILLER_49_499 VPWR VGND sg13g2_fill_1
XFILLER_36_105 VPWR VGND sg13g2_decap_8
XFILLER_44_182 VPWR VGND sg13g2_decap_8
XFILLER_32_333 VPWR VGND sg13g2_decap_8
XFILLER_9_584 VPWR VGND sg13g2_fill_2
X_1525_ VPWR _0161_ daisychain\[14\] VGND sg13g2_inv_1
X_1456_ VPWR _0237_ daisychain\[83\] VGND sg13g2_inv_1
XFILLER_19_18 VPWR VGND sg13g2_decap_8
X_1387_ VPWR _0044_ state\[24\] VGND sg13g2_inv_1
XFILLER_28_639 VPWR VGND sg13g2_fill_1
XFILLER_27_105 VPWR VGND sg13g2_decap_8
XFILLER_35_28 VPWR VGND sg13g2_decap_8
X_2008_ VGND VPWR net136 daisychain\[115\] _0864_ net43 sg13g2_a21oi_1
XFILLER_42_119 VPWR VGND sg13g2_decap_8
XFILLER_35_182 VPWR VGND sg13g2_decap_8
XFILLER_24_823 VPWR VGND sg13g2_decap_8
XFILLER_23_333 VPWR VGND sg13g2_decap_8
XFILLER_18_116 VPWR VGND sg13g2_decap_8
XFILLER_46_469 VPWR VGND sg13g2_decap_4
XFILLER_42_620 VPWR VGND sg13g2_fill_2
XFILLER_26_193 VPWR VGND sg13g2_decap_8
XFILLER_14_333 VPWR VGND sg13g2_decap_8
XFILLER_41_196 VPWR VGND sg13g2_decap_8
XFILLER_6_510 VPWR VGND sg13g2_decap_8
XFILLER_6_554 VPWR VGND sg13g2_decap_8
Xheichips25_pudding VPWR VGND uio_oe[0] sg13g2_tiehi
XFILLER_44_7 VPWR VGND sg13g2_decap_8
X_2290_ _1016_ net136 state\[118\] VPWR VGND sg13g2_nand2_1
X_1310_ VPWR _0002_ state\[101\] VGND sg13g2_inv_1
XFILLER_2_782 VPWR VGND sg13g2_fill_2
XFILLER_2_32 VPWR VGND sg13g2_decap_8
XFILLER_49_263 VPWR VGND sg13g2_decap_8
XFILLER_37_458 VPWR VGND sg13g2_fill_2
XFILLER_37_425 VPWR VGND sg13g2_decap_4
XFILLER_17_182 VPWR VGND sg13g2_decap_8
XFILLER_33_664 VPWR VGND sg13g2_decap_4
XFILLER_32_130 VPWR VGND sg13g2_decap_8
XANTENNA_15 VPWR VGND daisychain\[115\] sg13g2_antennanp
XANTENNA_26 VPWR VGND daisychain\[8\] sg13g2_antennanp
XANTENNA_37 VPWR VGND _0159_ sg13g2_antennanp
XANTENNA_48 VPWR VGND _0198_ sg13g2_antennanp
XFILLER_20_347 VPWR VGND sg13g2_decap_8
XANTENNA_59 VPWR VGND _0250_ sg13g2_antennanp
X_2557_ net279 VGND VPWR _0503_ state\[119\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2488_ net289 VGND VPWR _0434_ state\[50\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_1508_ VPWR _0180_ daisychain\[31\] VGND sg13g2_inv_1
X_1439_ VPWR _0129_ daisychain\[100\] VGND sg13g2_inv_1
XFILLER_29_926 VPWR VGND sg13g2_fill_1
XFILLER_46_49 VPWR VGND sg13g2_decap_8
XFILLER_44_918 VPWR VGND sg13g2_fill_2
XFILLER_23_130 VPWR VGND sg13g2_decap_8
XFILLER_11_347 VPWR VGND sg13g2_decap_8
XFILLER_7_329 VPWR VGND sg13g2_decap_8
X_2480__322 VPWR VGND net321 sg13g2_tiehi
XFILLER_11_74 VPWR VGND sg13g2_decap_8
XFILLER_3_557 VPWR VGND sg13g2_decap_8
XFILLER_47_767 VPWR VGND sg13g2_fill_2
XFILLER_46_266 VPWR VGND sg13g2_decap_8
XFILLER_28_970 VPWR VGND sg13g2_fill_2
XFILLER_14_130 VPWR VGND sg13g2_decap_8
X_1790_ net228 VPWR _0700_ VGND state\[62\] net198 sg13g2_o21ai_1
XFILLER_6_340 VPWR VGND sg13g2_decap_8
X_2411_ net286 VGND VPWR _0357_ daisychain\[101\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2342_ net424 VGND VPWR _0288_ daisychain\[32\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_2273_ VGND VPWR _0842_ _1007_ _0493_ net88 sg13g2_a21oi_1
XFILLER_37_266 VPWR VGND sg13g2_decap_8
XFILLER_32_18 VPWR VGND sg13g2_decap_8
XFILLER_21_656 VPWR VGND sg13g2_decap_8
XFILLER_20_144 VPWR VGND sg13g2_decap_8
X_1988_ VGND VPWR net134 daisychain\[110\] _0849_ net40 sg13g2_a21oi_1
XFILLER_28_200 VPWR VGND sg13g2_decap_8
Xclkbuf_2_2__f_clk clknet_2_2__leaf_clk clknet_0_clk VPWR VGND sg13g2_buf_16
XFILLER_43_203 VPWR VGND sg13g2_decap_8
XFILLER_28_277 VPWR VGND sg13g2_decap_8
XFILLER_16_417 VPWR VGND sg13g2_decap_8
XFILLER_11_144 VPWR VGND sg13g2_decap_8
XFILLER_8_616 VPWR VGND sg13g2_fill_1
XFILLER_8_605 VPWR VGND sg13g2_decap_8
XFILLER_7_126 VPWR VGND sg13g2_decap_8
XFILLER_22_95 VPWR VGND sg13g2_decap_8
XFILLER_4_866 VPWR VGND sg13g2_decap_8
XFILLER_3_354 VPWR VGND sg13g2_decap_8
XFILLER_0_0 VPWR VGND sg13g2_decap_8
XFILLER_4_888 VPWR VGND sg13g2_fill_1
Xfanout190 net191 net190 VPWR VGND sg13g2_buf_1
XFILLER_19_200 VPWR VGND sg13g2_decap_8
XFILLER_47_70 VPWR VGND sg13g2_decap_8
XFILLER_47_553 VPWR VGND sg13g2_decap_8
XFILLER_34_214 VPWR VGND sg13g2_decap_8
XFILLER_19_277 VPWR VGND sg13g2_decap_8
X_1911_ net204 _0247_ _0790_ _0791_ VPWR VGND sg13g2_a21o_1
XFILLER_42_280 VPWR VGND sg13g2_decap_8
X_1842_ net229 VPWR _0739_ VGND state\[75\] net202 sg13g2_o21ai_1
X_2348__413 VPWR VGND net412 sg13g2_tiehi
XFILLER_8_53 VPWR VGND sg13g2_decap_8
X_1773_ VPWR VGND _0687_ net105 _0686_ _0208_ _0313_ net56 sg13g2_a221oi_1
X_2325_ net458 VGND VPWR _0271_ daisychain\[15\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2256_ _0999_ net139 state\[101\] VPWR VGND sg13g2_nand2_1
X_2187_ VGND VPWR _0713_ _0964_ _0450_ net113 sg13g2_a21oi_1
XFILLER_25_214 VPWR VGND sg13g2_decap_8
XFILLER_43_28 VPWR VGND sg13g2_decap_8
XFILLER_40_217 VPWR VGND sg13g2_decap_8
XFILLER_33_291 VPWR VGND sg13g2_decap_8
XFILLER_22_976 VPWR VGND sg13g2_fill_2
XFILLER_21_475 VPWR VGND sg13g2_decap_4
X_2399__311 VPWR VGND net310 sg13g2_tiehi
XFILLER_0_357 VPWR VGND sg13g2_decap_8
XFILLER_44_501 VPWR VGND sg13g2_decap_8
XFILLER_29_586 VPWR VGND sg13g2_decap_8
XFILLER_17_715 VPWR VGND sg13g2_decap_4
XFILLER_16_214 VPWR VGND sg13g2_decap_8
XFILLER_17_84 VPWR VGND sg13g2_decap_8
XFILLER_31_228 VPWR VGND sg13g2_decap_8
XFILLER_12_431 VPWR VGND sg13g2_decap_8
XFILLER_24_291 VPWR VGND sg13g2_decap_8
XFILLER_8_424 VPWR VGND sg13g2_decap_8
XFILLER_3_151 VPWR VGND sg13g2_decap_8
XFILLER_0_891 VPWR VGND sg13g2_fill_2
X_2110_ _0926_ net120 state\[28\] VPWR VGND sg13g2_nand2_1
X_2041_ VPWR VGND _0888_ net72 _0887_ _0155_ _0380_ net26 sg13g2_a221oi_1
XFILLER_47_350 VPWR VGND sg13g2_decap_8
XFILLER_22_228 VPWR VGND sg13g2_decap_8
XFILLER_15_291 VPWR VGND sg13g2_decap_8
X_1825_ VPWR VGND _0726_ net113 _0725_ _0223_ _0326_ net67 sg13g2_a221oi_1
X_1756_ VGND VPWR net150 daisychain\[52\] _0675_ net54 sg13g2_a21oi_1
X_1687_ net169 _0185_ _0622_ _0623_ VPWR VGND sg13g2_a21o_1
X_2308_ _1025_ state\[127\] net116 VPWR VGND sg13g2_nand2_1
XFILLER_38_28 VPWR VGND sg13g2_decap_8
X_2239_ VGND VPWR _0791_ _0990_ _0476_ net109 sg13g2_a21oi_1
XFILLER_38_350 VPWR VGND sg13g2_decap_8
X_2552__440 VPWR VGND net439 sg13g2_tiehi
XFILLER_26_578 VPWR VGND sg13g2_decap_8
XFILLER_13_228 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_491 VPWR VGND uio_oe[2] sg13g2_tiehi
XFILLER_41_559 VPWR VGND sg13g2_fill_1
XFILLER_5_438 VPWR VGND sg13g2_decap_8
XFILLER_5_449 VPWR VGND sg13g2_fill_1
XFILLER_1_644 VPWR VGND sg13g2_decap_8
XFILLER_0_154 VPWR VGND sg13g2_decap_8
XFILLER_1_655 VPWR VGND sg13g2_fill_1
XFILLER_49_648 VPWR VGND sg13g2_decap_8
XFILLER_48_147 VPWR VGND sg13g2_decap_8
XFILLER_29_361 VPWR VGND sg13g2_decap_8
XFILLER_17_512 VPWR VGND sg13g2_decap_8
XFILLER_44_364 VPWR VGND sg13g2_decap_8
XFILLER_17_578 VPWR VGND sg13g2_decap_4
XFILLER_8_221 VPWR VGND sg13g2_decap_8
X_1610_ net212 VPWR _0565_ VGND state\[17\] net164 sg13g2_o21ai_1
XFILLER_8_298 VPWR VGND sg13g2_decap_8
X_1541_ net215 VPWR _0513_ VGND state\[0\] net176 sg13g2_o21ai_1
XFILLER_5_32 VPWR VGND sg13g2_decap_8
X_1472_ VPWR _0219_ daisychain\[67\] VGND sg13g2_inv_1
XFILLER_4_482 VPWR VGND sg13g2_decap_8
XFILLER_39_147 VPWR VGND sg13g2_decap_8
X_2024_ VGND VPWR net130 daisychain\[119\] _0876_ net37 sg13g2_a21oi_1
XFILLER_35_364 VPWR VGND sg13g2_fill_2
X_1808_ VGND VPWR net160 daisychain\[65\] _0714_ net66 sg13g2_a21oi_1
X_1739_ net195 _0199_ _0661_ _0662_ VPWR VGND sg13g2_a21o_1
XFILLER_46_1019 VPWR VGND sg13g2_decap_8
XFILLER_39_681 VPWR VGND sg13g2_decap_4
XFILLER_27_810 VPWR VGND sg13g2_fill_2
XANTENNA_105 VPWR VGND daisychain\[25\] sg13g2_antennanp
XANTENNA_116 VPWR VGND _0177_ sg13g2_antennanp
XANTENNA_127 VPWR VGND daisychain\[35\] sg13g2_antennanp
XFILLER_41_301 VPWR VGND sg13g2_decap_8
XFILLER_14_74 VPWR VGND sg13g2_decap_8
XFILLER_5_235 VPWR VGND sg13g2_decap_8
XFILLER_30_95 VPWR VGND sg13g2_decap_8
XFILLER_1_441 VPWR VGND sg13g2_decap_8
XFILLER_2_997 VPWR VGND sg13g2_decap_4
XFILLER_49_445 VPWR VGND sg13g2_decap_8
X_2455__422 VPWR VGND net421 sg13g2_tiehi
XFILLER_17_364 VPWR VGND sg13g2_decap_4
XFILLER_44_161 VPWR VGND sg13g2_decap_8
XFILLER_32_312 VPWR VGND sg13g2_decap_8
XFILLER_17_386 VPWR VGND sg13g2_decap_8
XFILLER_9_530 VPWR VGND sg13g2_decap_8
X_1524_ VPWR _0162_ daisychain\[15\] VGND sg13g2_inv_1
X_1455_ VPWR _0238_ daisychain\[84\] VGND sg13g2_inv_1
X_1386_ VPWR _0045_ state\[25\] VGND sg13g2_inv_1
XFILLER_49_990 VPWR VGND sg13g2_decap_8
X_2007_ net181 _0146_ _0862_ _0863_ VPWR VGND sg13g2_a21o_1
X_2356__397 VPWR VGND net396 sg13g2_tiehi
XFILLER_35_161 VPWR VGND sg13g2_decap_8
XFILLER_24_835 VPWR VGND sg13g2_fill_2
XFILLER_23_312 VPWR VGND sg13g2_decap_8
XFILLER_24_879 VPWR VGND sg13g2_fill_1
XFILLER_23_389 VPWR VGND sg13g2_decap_8
XFILLER_2_249 VPWR VGND sg13g2_decap_8
XFILLER_47_905 VPWR VGND sg13g2_fill_1
XFILLER_19_629 VPWR VGND sg13g2_fill_2
XFILLER_46_448 VPWR VGND sg13g2_decap_8
X_2554__376 VPWR VGND net375 sg13g2_tiehi
XFILLER_33_109 VPWR VGND sg13g2_decap_8
XFILLER_26_172 VPWR VGND sg13g2_decap_8
XFILLER_14_312 VPWR VGND sg13g2_decap_8
XFILLER_41_175 VPWR VGND sg13g2_decap_8
XFILLER_25_95 VPWR VGND sg13g2_decap_8
XFILLER_14_389 VPWR VGND sg13g2_decap_8
XFILLER_37_7 VPWR VGND sg13g2_decap_8
XFILLER_2_772 VPWR VGND sg13g2_decap_4
XFILLER_2_761 VPWR VGND sg13g2_decap_8
XFILLER_49_242 VPWR VGND sg13g2_decap_8
XFILLER_2_11 VPWR VGND sg13g2_decap_8
XFILLER_2_88 VPWR VGND sg13g2_decap_8
XFILLER_24_109 VPWR VGND sg13g2_decap_8
XFILLER_17_161 VPWR VGND sg13g2_decap_8
XANTENNA_16 VPWR VGND daisychain\[120\] sg13g2_antennanp
XANTENNA_27 VPWR VGND daisychain\[97\] sg13g2_antennanp
XANTENNA_38 VPWR VGND _0175_ sg13g2_antennanp
XFILLER_32_186 VPWR VGND sg13g2_decap_8
XFILLER_20_326 VPWR VGND sg13g2_decap_8
XANTENNA_49 VPWR VGND _0224_ sg13g2_antennanp
XFILLER_9_382 VPWR VGND sg13g2_decap_8
XFILLER_0_709 VPWR VGND sg13g2_decap_8
X_2556_ net311 VGND VPWR _0502_ state\[118\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2487_ net293 VGND VPWR _0433_ state\[49\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1507_ VPWR _0181_ daisychain\[32\] VGND sg13g2_inv_1
X_1438_ VPWR _0130_ daisychain\[101\] VGND sg13g2_inv_1
X_1369_ VPWR _0064_ state\[42\] VGND sg13g2_inv_1
XFILLER_46_28 VPWR VGND sg13g2_decap_8
XFILLER_28_437 VPWR VGND sg13g2_fill_2
XFILLER_43_429 VPWR VGND sg13g2_decap_8
XFILLER_15_109 VPWR VGND sg13g2_decap_8
XFILLER_11_326 VPWR VGND sg13g2_decap_8
XFILLER_23_186 VPWR VGND sg13g2_decap_8
XFILLER_7_308 VPWR VGND sg13g2_decap_8
XFILLER_11_53 VPWR VGND sg13g2_decap_8
XFILLER_3_536 VPWR VGND sg13g2_decap_8
XFILLER_2_4 VPWR VGND sg13g2_decap_8
XFILLER_4_1005 VPWR VGND sg13g2_fill_1
XFILLER_19_448 VPWR VGND sg13g2_decap_4
XFILLER_46_245 VPWR VGND sg13g2_decap_8
XFILLER_27_470 VPWR VGND sg13g2_fill_1
XFILLER_14_186 VPWR VGND sg13g2_decap_8
X_2410_ net288 VGND VPWR _0356_ daisychain\[100\] clknet_leaf_7_clk sg13g2_dfrbpq_1
XFILLER_6_396 VPWR VGND sg13g2_fill_2
X_2341_ net426 VGND VPWR _0287_ daisychain\[31\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_2272_ _1007_ net135 state\[109\] VPWR VGND sg13g2_nand2_1
XFILLER_37_245 VPWR VGND sg13g2_decap_8
XFILLER_20_123 VPWR VGND sg13g2_decap_8
X_1987_ net179 _0141_ _0847_ _0848_ VPWR VGND sg13g2_a21o_1
X_2539_ net415 VGND VPWR _0485_ state\[101\] clknet_leaf_7_clk sg13g2_dfrbpq_1
XFILLER_0_539 VPWR VGND sg13g2_decap_8
XFILLER_28_256 VPWR VGND sg13g2_decap_8
XFILLER_43_259 VPWR VGND sg13g2_decap_8
XFILLER_11_123 VPWR VGND sg13g2_decap_8
XFILLER_7_105 VPWR VGND sg13g2_decap_8
XFILLER_22_74 VPWR VGND sg13g2_decap_8
XFILLER_3_333 VPWR VGND sg13g2_decap_8
Xfanout191 net192 net191 VPWR VGND sg13g2_buf_1
Xfanout180 net182 net180 VPWR VGND sg13g2_buf_1
XFILLER_19_256 VPWR VGND sg13g2_decap_8
XFILLER_47_576 VPWR VGND sg13g2_decap_8
XFILLER_15_451 VPWR VGND sg13g2_fill_1
X_1910_ net230 VPWR _0790_ VGND state\[92\] net203 sg13g2_o21ai_1
X_1841_ VPWR VGND _0738_ net107 _0737_ _0227_ _0330_ net63 sg13g2_a221oi_1
XFILLER_8_32 VPWR VGND sg13g2_decap_8
X_1772_ VGND VPWR net152 daisychain\[56\] _0687_ net56 sg13g2_a21oi_1
XFILLER_7_661 VPWR VGND sg13g2_decap_8
XFILLER_7_683 VPWR VGND sg13g2_decap_4
XFILLER_6_193 VPWR VGND sg13g2_decap_8
X_2324_ net460 VGND VPWR _0270_ daisychain\[14\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2255_ VGND VPWR _0815_ _0998_ _0484_ net92 sg13g2_a21oi_1
X_2186_ _0964_ net161 state\[66\] VPWR VGND sg13g2_nand2_1
XFILLER_33_270 VPWR VGND sg13g2_decap_8
XFILLER_21_421 VPWR VGND sg13g2_fill_2
XFILLER_21_454 VPWR VGND sg13g2_fill_2
XFILLER_49_1028 VPWR VGND sg13g2_fill_1
XFILLER_0_336 VPWR VGND sg13g2_decap_8
XFILLER_48_329 VPWR VGND sg13g2_decap_8
X_2553__408 VPWR VGND net407 sg13g2_tiehi
XFILLER_29_554 VPWR VGND sg13g2_decap_8
XFILLER_29_565 VPWR VGND sg13g2_fill_1
XFILLER_44_546 VPWR VGND sg13g2_fill_1
XFILLER_17_63 VPWR VGND sg13g2_decap_8
XFILLER_31_207 VPWR VGND sg13g2_decap_8
XFILLER_12_410 VPWR VGND sg13g2_decap_8
XFILLER_24_270 VPWR VGND sg13g2_decap_8
XFILLER_8_403 VPWR VGND sg13g2_decap_8
XFILLER_12_487 VPWR VGND sg13g2_decap_8
XFILLER_33_95 VPWR VGND sg13g2_decap_8
XFILLER_4_620 VPWR VGND sg13g2_fill_2
XFILLER_3_130 VPWR VGND sg13g2_decap_8
XFILLER_4_697 VPWR VGND sg13g2_fill_2
XFILLER_0_870 VPWR VGND sg13g2_fill_2
XFILLER_39_329 VPWR VGND sg13g2_decap_8
X_2040_ VGND VPWR net116 daisychain\[123\] _0888_ net26 sg13g2_a21oi_1
XFILLER_22_207 VPWR VGND sg13g2_decap_8
XFILLER_15_270 VPWR VGND sg13g2_decap_8
X_2315__479 VPWR VGND net478 sg13g2_tiehi
X_1824_ VGND VPWR net161 daisychain\[69\] _0726_ net66 sg13g2_a21oi_1
XFILLER_30_284 VPWR VGND sg13g2_decap_8
X_1755_ net194 _0204_ _0673_ _0674_ VPWR VGND sg13g2_a21o_1
X_1686_ net214 VPWR _0622_ VGND state\[36\] net169 sg13g2_o21ai_1
X_2307_ VGND VPWR _0893_ _1024_ _0510_ net82 sg13g2_a21oi_1
X_2238_ _0990_ net156 state\[92\] VPWR VGND sg13g2_nand2_1
X_2169_ VGND VPWR _0686_ _0955_ _0441_ net104 sg13g2_a21oi_1
XFILLER_26_524 VPWR VGND sg13g2_fill_2
XFILLER_13_207 VPWR VGND sg13g2_decap_8
XFILLER_14_708 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_492 VPWR VGND uio_oe[3] sg13g2_tiehi
XFILLER_21_284 VPWR VGND sg13g2_decap_8
XFILLER_5_417 VPWR VGND sg13g2_decap_8
X_2366__377 VPWR VGND net376 sg13g2_tiehi
XFILLER_1_623 VPWR VGND sg13g2_decap_8
XFILLER_0_133 VPWR VGND sg13g2_decap_8
XFILLER_49_627 VPWR VGND sg13g2_fill_1
XFILLER_48_126 VPWR VGND sg13g2_decap_8
XFILLER_29_340 VPWR VGND sg13g2_decap_8
XFILLER_28_95 VPWR VGND sg13g2_decap_8
XFILLER_44_343 VPWR VGND sg13g2_decap_8
XFILLER_8_200 VPWR VGND sg13g2_decap_8
XFILLER_12_284 VPWR VGND sg13g2_decap_8
XFILLER_8_277 VPWR VGND sg13g2_decap_8
X_1540_ VPWR _0512_ net1 VGND sg13g2_inv_1
XFILLER_5_951 VPWR VGND sg13g2_fill_1
XFILLER_5_11 VPWR VGND sg13g2_decap_8
XFILLER_4_461 VPWR VGND sg13g2_decap_8
X_1471_ VPWR _0220_ daisychain\[68\] VGND sg13g2_inv_1
XFILLER_5_88 VPWR VGND sg13g2_decap_8
XFILLER_39_126 VPWR VGND sg13g2_decap_8
X_2023_ net175 _0151_ _0874_ _0875_ VPWR VGND sg13g2_a21o_1
XFILLER_35_343 VPWR VGND sg13g2_decap_8
X_1807_ net205 _0218_ _0712_ _0713_ VPWR VGND sg13g2_a21o_1
X_1738_ net224 VPWR _0661_ VGND state\[49\] net194 sg13g2_o21ai_1
X_1669_ VPWR VGND _0609_ net100 _0608_ _0180_ _0287_ net55 sg13g2_a221oi_1
XFILLER_49_39 VPWR VGND sg13g2_decap_8
XANTENNA_106 VPWR VGND daisychain\[25\] sg13g2_antennanp
XANTENNA_117 VPWR VGND _0177_ sg13g2_antennanp
XANTENNA_128 VPWR VGND daisychain\[35\] sg13g2_antennanp
XFILLER_26_354 VPWR VGND sg13g2_decap_8
XFILLER_41_357 VPWR VGND sg13g2_decap_8
XFILLER_14_53 VPWR VGND sg13g2_decap_8
X_2483__310 VPWR VGND net309 sg13g2_tiehi
XFILLER_5_214 VPWR VGND sg13g2_decap_8
XFILLER_30_74 VPWR VGND sg13g2_decap_8
XFILLER_2_965 VPWR VGND sg13g2_fill_2
XFILLER_1_420 VPWR VGND sg13g2_decap_8
XFILLER_49_424 VPWR VGND sg13g2_decap_8
XFILLER_1_497 VPWR VGND sg13g2_decap_8
XFILLER_37_619 VPWR VGND sg13g2_decap_8
X_2535__480 VPWR VGND net479 sg13g2_tiehi
XFILLER_45_652 VPWR VGND sg13g2_decap_8
XFILLER_44_140 VPWR VGND sg13g2_decap_8
XFILLER_17_343 VPWR VGND sg13g2_decap_8
XFILLER_32_368 VPWR VGND sg13g2_decap_8
XFILLER_9_586 VPWR VGND sg13g2_fill_1
X_1523_ VPWR _0163_ daisychain\[16\] VGND sg13g2_inv_1
X_1454_ VPWR _0239_ daisychain\[85\] VGND sg13g2_inv_1
XFILLER_4_291 VPWR VGND sg13g2_decap_8
X_1385_ VPWR _0046_ state\[26\] VGND sg13g2_inv_1
X_2006_ net217 VPWR _0862_ VGND state\[116\] net181 sg13g2_o21ai_1
XFILLER_35_140 VPWR VGND sg13g2_decap_8
X_2510__428 VPWR VGND net427 sg13g2_tiehi
XFILLER_11_508 VPWR VGND sg13g2_fill_2
XFILLER_11_519 VPWR VGND sg13g2_fill_2
XFILLER_23_368 VPWR VGND sg13g2_decap_8
X_2839_ daisychain\[121\] net17 VPWR VGND sg13g2_buf_1
XFILLER_2_228 VPWR VGND sg13g2_decap_8
XFILLER_46_427 VPWR VGND sg13g2_decap_8
XFILLER_27_641 VPWR VGND sg13g2_decap_4
XFILLER_26_151 VPWR VGND sg13g2_decap_8
XFILLER_41_154 VPWR VGND sg13g2_decap_8
XFILLER_25_74 VPWR VGND sg13g2_decap_8
XFILLER_14_368 VPWR VGND sg13g2_decap_8
XFILLER_10_596 VPWR VGND sg13g2_fill_1
XFILLER_6_545 VPWR VGND sg13g2_decap_4
XFILLER_41_84 VPWR VGND sg13g2_decap_8
XFILLER_29_1015 VPWR VGND sg13g2_fill_1
XFILLER_29_1026 VPWR VGND sg13g2_fill_2
XFILLER_2_784 VPWR VGND sg13g2_fill_1
XFILLER_49_221 VPWR VGND sg13g2_decap_8
XFILLER_1_294 VPWR VGND sg13g2_decap_8
XFILLER_2_67 VPWR VGND sg13g2_decap_8
XFILLER_49_298 VPWR VGND sg13g2_decap_8
XFILLER_46_961 VPWR VGND sg13g2_fill_2
XFILLER_33_622 VPWR VGND sg13g2_decap_8
XFILLER_17_140 VPWR VGND sg13g2_decap_8
XFILLER_33_633 VPWR VGND sg13g2_fill_1
XFILLER_32_165 VPWR VGND sg13g2_decap_8
XFILLER_20_305 VPWR VGND sg13g2_decap_8
XANTENNA_17 VPWR VGND daisychain\[120\] sg13g2_antennanp
XANTENNA_28 VPWR VGND daisychain\[97\] sg13g2_antennanp
XANTENNA_39 VPWR VGND _0177_ sg13g2_antennanp
XFILLER_9_361 VPWR VGND sg13g2_decap_8
X_2555_ net343 VGND VPWR _0501_ state\[117\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2486_ net297 VGND VPWR _0432_ state\[48\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1506_ VPWR _0182_ daisychain\[33\] VGND sg13g2_inv_1
X_1437_ VPWR _0131_ daisychain\[102\] VGND sg13g2_inv_1
X_1368_ VPWR _0065_ state\[43\] VGND sg13g2_inv_1
XFILLER_29_939 VPWR VGND sg13g2_fill_1
X_1299_ VPWR _0014_ state\[112\] VGND sg13g2_inv_1
XFILLER_43_419 VPWR VGND sg13g2_fill_1
XFILLER_24_655 VPWR VGND sg13g2_fill_2
XFILLER_11_305 VPWR VGND sg13g2_decap_8
XFILLER_23_165 VPWR VGND sg13g2_decap_8
XFILLER_11_32 VPWR VGND sg13g2_decap_8
XFILLER_3_515 VPWR VGND sg13g2_decap_8
X_2560__392 VPWR VGND net391 sg13g2_tiehi
XFILLER_46_224 VPWR VGND sg13g2_decap_8
XFILLER_47_769 VPWR VGND sg13g2_fill_1
XFILLER_15_600 VPWR VGND sg13g2_decap_4
XFILLER_36_84 VPWR VGND sg13g2_decap_8
XFILLER_27_493 VPWR VGND sg13g2_decap_4
XFILLER_14_165 VPWR VGND sg13g2_decap_8
XFILLER_10_382 VPWR VGND sg13g2_decap_8
XFILLER_10_393 VPWR VGND sg13g2_decap_8
XFILLER_6_375 VPWR VGND sg13g2_decap_8
X_2340_ net428 VGND VPWR _0286_ daisychain\[30\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_2271_ VGND VPWR _0839_ _1006_ _0492_ net88 sg13g2_a21oi_1
XFILLER_28_4 VPWR VGND sg13g2_decap_8
XFILLER_37_224 VPWR VGND sg13g2_decap_8
XFILLER_21_603 VPWR VGND sg13g2_decap_8
XFILLER_20_102 VPWR VGND sg13g2_decap_8
X_1986_ net216 VPWR _0847_ VGND state\[111\] net178 sg13g2_o21ai_1
XFILLER_20_179 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_9_clk clknet_2_3__leaf_clk clknet_leaf_9_clk VPWR VGND sg13g2_buf_8
XFILLER_0_518 VPWR VGND sg13g2_decap_8
X_2325__459 VPWR VGND net458 sg13g2_tiehi
X_2538_ net431 VGND VPWR _0484_ state\[100\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2469_ net365 VGND VPWR _0415_ state\[31\] clknet_leaf_14_clk sg13g2_dfrbpq_1
XFILLER_29_747 VPWR VGND sg13g2_decap_4
XFILLER_29_769 VPWR VGND sg13g2_decap_4
XFILLER_28_235 VPWR VGND sg13g2_decap_8
XFILLER_43_238 VPWR VGND sg13g2_decap_8
XFILLER_24_441 VPWR VGND sg13g2_fill_1
XFILLER_11_102 VPWR VGND sg13g2_decap_8
XFILLER_24_496 VPWR VGND sg13g2_fill_2
XFILLER_24_474 VPWR VGND sg13g2_fill_2
XFILLER_11_179 VPWR VGND sg13g2_decap_8
XFILLER_22_53 VPWR VGND sg13g2_decap_8
XFILLER_3_312 VPWR VGND sg13g2_decap_8
XFILLER_3_389 VPWR VGND sg13g2_decap_8
Xfanout192 net5 net192 VPWR VGND sg13g2_buf_1
Xfanout181 net182 net181 VPWR VGND sg13g2_buf_1
Xfanout170 net171 net170 VPWR VGND sg13g2_buf_1
X_2376__357 VPWR VGND net356 sg13g2_tiehi
XFILLER_19_235 VPWR VGND sg13g2_decap_8
XFILLER_34_249 VPWR VGND sg13g2_decap_8
XFILLER_15_496 VPWR VGND sg13g2_fill_2
X_1840_ VGND VPWR net154 daisychain\[73\] _0738_ net59 sg13g2_a21oi_1
XFILLER_8_11 VPWR VGND sg13g2_decap_8
XFILLER_30_433 VPWR VGND sg13g2_fill_2
XFILLER_30_466 VPWR VGND sg13g2_decap_8
X_1771_ net199 _0208_ _0685_ _0686_ VPWR VGND sg13g2_a21o_1
XFILLER_8_88 VPWR VGND sg13g2_decap_8
XFILLER_6_172 VPWR VGND sg13g2_decap_8
X_2323_ net462 VGND VPWR _0269_ daisychain\[13\] clknet_leaf_17_clk sg13g2_dfrbpq_1
XFILLER_3_890 VPWR VGND sg13g2_fill_1
X_2254_ _0998_ net139 state\[100\] VPWR VGND sg13g2_nand2_1
X_2185_ VGND VPWR _0710_ _0963_ _0449_ net114 sg13g2_a21oi_1
XFILLER_38_555 VPWR VGND sg13g2_fill_2
XFILLER_25_249 VPWR VGND sg13g2_decap_8
XFILLER_22_901 VPWR VGND sg13g2_fill_1
X_1969_ VPWR VGND _0834_ net87 _0833_ _0135_ _0362_ net41 sg13g2_a221oi_1
XFILLER_4_109 VPWR VGND sg13g2_decap_8
XFILLER_0_315 VPWR VGND sg13g2_decap_8
XFILLER_48_308 VPWR VGND sg13g2_decap_8
XFILLER_17_42 VPWR VGND sg13g2_decap_8
XFILLER_25_750 VPWR VGND sg13g2_decap_4
XFILLER_16_249 VPWR VGND sg13g2_decap_8
XFILLER_12_466 VPWR VGND sg13g2_decap_8
XFILLER_33_74 VPWR VGND sg13g2_decap_8
XFILLER_8_459 VPWR VGND sg13g2_decap_8
XFILLER_3_186 VPWR VGND sg13g2_decap_8
XFILLER_39_308 VPWR VGND sg13g2_decap_8
XFILLER_0_893 VPWR VGND sg13g2_fill_1
X_2458__410 VPWR VGND net409 sg13g2_tiehi
XFILLER_48_831 VPWR VGND sg13g2_decap_4
XFILLER_47_385 VPWR VGND sg13g2_decap_8
XFILLER_30_263 VPWR VGND sg13g2_decap_8
X_1823_ net205 _0223_ _0724_ _0725_ VPWR VGND sg13g2_a21o_1
X_1754_ net225 VPWR _0673_ VGND state\[53\] net193 sg13g2_o21ai_1
X_1685_ VPWR VGND _0621_ net74 _0620_ _0184_ _0291_ net28 sg13g2_a221oi_1
X_2306_ _1024_ net129 state\[126\] VPWR VGND sg13g2_nand2_1
X_2237_ VGND VPWR _0788_ _0989_ _0475_ net109 sg13g2_a21oi_1
X_2168_ _0955_ net151 state\[57\] VPWR VGND sg13g2_nand2_1
X_2513__404 VPWR VGND net403 sg13g2_tiehi
X_2099_ VGND VPWR _0581_ _0920_ _0406_ net91 sg13g2_a21oi_1
XFILLER_41_506 VPWR VGND sg13g2_decap_4
Xheichips25_pudding_493 VPWR VGND uio_oe[4] sg13g2_tiehi
XFILLER_21_263 VPWR VGND sg13g2_decap_8
XFILLER_1_602 VPWR VGND sg13g2_decap_8
XFILLER_0_112 VPWR VGND sg13g2_decap_8
XFILLER_49_606 VPWR VGND sg13g2_decap_8
XFILLER_48_105 VPWR VGND sg13g2_decap_8
XFILLER_0_189 VPWR VGND sg13g2_decap_8
XFILLER_28_74 VPWR VGND sg13g2_decap_8
XFILLER_44_322 VPWR VGND sg13g2_decap_8
XFILLER_29_374 VPWR VGND sg13g2_fill_2
XFILLER_44_399 VPWR VGND sg13g2_decap_8
XFILLER_44_84 VPWR VGND sg13g2_decap_8
XFILLER_12_263 VPWR VGND sg13g2_decap_8
X_2525__308 VPWR VGND net307 sg13g2_tiehi
XFILLER_8_256 VPWR VGND sg13g2_decap_8
XFILLER_5_930 VPWR VGND sg13g2_fill_2
X_1470_ VPWR _0221_ daisychain\[69\] VGND sg13g2_inv_1
XFILLER_5_67 VPWR VGND sg13g2_decap_8
XFILLER_39_105 VPWR VGND sg13g2_decap_8
XFILLER_10_4 VPWR VGND sg13g2_decap_8
XFILLER_48_650 VPWR VGND sg13g2_decap_8
X_2022_ net215 VPWR _0874_ VGND state\[120\] net175 sg13g2_o21ai_1
XFILLER_47_182 VPWR VGND sg13g2_decap_8
XFILLER_35_322 VPWR VGND sg13g2_decap_8
X_1806_ net231 VPWR _0712_ VGND state\[66\] net205 sg13g2_o21ai_1
X_1737_ VPWR VGND _0660_ net102 _0659_ _0198_ _0304_ net53 sg13g2_a221oi_1
X_1668_ VGND VPWR net147 daisychain\[30\] _0609_ net55 sg13g2_a21oi_1
XFILLER_49_18 VPWR VGND sg13g2_decap_8
X_1599_ net168 _0161_ _0556_ _0557_ VPWR VGND sg13g2_a21o_1
XANTENNA_107 VPWR VGND daisychain\[27\] sg13g2_antennanp
XFILLER_45_119 VPWR VGND sg13g2_decap_8
XFILLER_39_694 VPWR VGND sg13g2_fill_2
XFILLER_38_182 VPWR VGND sg13g2_decap_8
XFILLER_27_834 VPWR VGND sg13g2_fill_1
XFILLER_27_823 VPWR VGND sg13g2_fill_1
XANTENNA_118 VPWR VGND _0182_ sg13g2_antennanp
XANTENNA_129 VPWR VGND daisychain\[39\] sg13g2_antennanp
XFILLER_26_333 VPWR VGND sg13g2_decap_8
XFILLER_41_336 VPWR VGND sg13g2_decap_8
XFILLER_14_32 VPWR VGND sg13g2_decap_8
XFILLER_30_53 VPWR VGND sg13g2_decap_8
XFILLER_2_922 VPWR VGND sg13g2_decap_8
XFILLER_49_403 VPWR VGND sg13g2_decap_8
XFILLER_1_476 VPWR VGND sg13g2_decap_8
XFILLER_39_84 VPWR VGND sg13g2_decap_8
XFILLER_36_119 VPWR VGND sg13g2_decap_8
XFILLER_17_322 VPWR VGND sg13g2_decap_8
XFILLER_29_193 VPWR VGND sg13g2_decap_8
XFILLER_45_686 VPWR VGND sg13g2_fill_2
XFILLER_44_196 VPWR VGND sg13g2_decap_8
XFILLER_32_347 VPWR VGND sg13g2_decap_8
XFILLER_13_561 VPWR VGND sg13g2_decap_8
XFILLER_9_565 VPWR VGND sg13g2_fill_1
X_1522_ VPWR _0164_ daisychain\[17\] VGND sg13g2_inv_1
X_1453_ VPWR _0240_ daisychain\[86\] VGND sg13g2_inv_1
XFILLER_4_270 VPWR VGND sg13g2_decap_8
X_1384_ VPWR _0047_ state\[27\] VGND sg13g2_inv_1
XFILLER_27_119 VPWR VGND sg13g2_decap_8
X_2005_ VPWR VGND _0861_ net83 _0860_ _0145_ _0371_ net37 sg13g2_a221oi_1
XFILLER_35_196 VPWR VGND sg13g2_decap_8
XFILLER_23_347 VPWR VGND sg13g2_decap_8
X_2838_ daisychain\[120\] net16 VPWR VGND sg13g2_buf_1
X_2404__301 VPWR VGND net300 sg13g2_tiehi
XFILLER_2_207 VPWR VGND sg13g2_decap_8
XFILLER_46_406 VPWR VGND sg13g2_decap_8
XFILLER_26_130 VPWR VGND sg13g2_decap_8
X_2335__439 VPWR VGND net438 sg13g2_tiehi
XFILLER_42_656 VPWR VGND sg13g2_fill_2
XFILLER_25_53 VPWR VGND sg13g2_decap_8
XFILLER_14_347 VPWR VGND sg13g2_decap_8
XFILLER_41_133 VPWR VGND sg13g2_decap_8
XFILLER_6_524 VPWR VGND sg13g2_decap_8
XFILLER_41_63 VPWR VGND sg13g2_decap_8
XFILLER_6_568 VPWR VGND sg13g2_decap_8
XFILLER_49_200 VPWR VGND sg13g2_decap_8
XFILLER_2_796 VPWR VGND sg13g2_decap_8
XFILLER_1_273 VPWR VGND sg13g2_decap_8
XFILLER_2_46 VPWR VGND sg13g2_decap_8
XFILLER_49_277 VPWR VGND sg13g2_decap_8
XFILLER_45_494 VPWR VGND sg13g2_fill_1
XFILLER_17_196 VPWR VGND sg13g2_decap_8
XFILLER_32_144 VPWR VGND sg13g2_decap_8
XFILLER_21_807 VPWR VGND sg13g2_fill_1
XANTENNA_18 VPWR VGND daisychain\[17\] sg13g2_antennanp
XANTENNA_29 VPWR VGND _0128_ sg13g2_antennanp
X_2386__337 VPWR VGND net336 sg13g2_tiehi
XFILLER_9_340 VPWR VGND sg13g2_decap_8
X_2554_ net375 VGND VPWR _0500_ state\[116\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_1505_ VPWR _0183_ daisychain\[34\] VGND sg13g2_inv_1
X_2485_ net301 VGND VPWR _0431_ state\[47\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1436_ VPWR _0132_ daisychain\[103\] VGND sg13g2_inv_1
X_1367_ VPWR _0066_ state\[44\] VGND sg13g2_inv_1
XFILLER_28_439 VPWR VGND sg13g2_fill_1
X_1298_ VPWR _0015_ state\[113\] VGND sg13g2_inv_1
XFILLER_24_623 VPWR VGND sg13g2_decap_8
XFILLER_23_144 VPWR VGND sg13g2_decap_8
XFILLER_11_11 VPWR VGND sg13g2_decap_8
XFILLER_11_88 VPWR VGND sg13g2_decap_8
XFILLER_4_1018 VPWR VGND sg13g2_decap_8
XFILLER_47_737 VPWR VGND sg13g2_decap_8
XFILLER_46_203 VPWR VGND sg13g2_decap_8
XFILLER_36_63 VPWR VGND sg13g2_decap_8
XFILLER_15_623 VPWR VGND sg13g2_fill_1
XFILLER_14_144 VPWR VGND sg13g2_decap_8
XFILLER_30_615 VPWR VGND sg13g2_decap_8
XFILLER_10_361 VPWR VGND sg13g2_decap_8
XFILLER_6_354 VPWR VGND sg13g2_decap_8
XFILLER_42_7 VPWR VGND sg13g2_decap_8
X_2270_ _1006_ net135 state\[108\] VPWR VGND sg13g2_nand2_1
XFILLER_2_593 VPWR VGND sg13g2_decap_8
XFILLER_37_203 VPWR VGND sg13g2_decap_8
XFILLER_46_792 VPWR VGND sg13g2_decap_4
XFILLER_45_280 VPWR VGND sg13g2_decap_8
XFILLER_33_442 VPWR VGND sg13g2_decap_8
X_1985_ VPWR VGND _0846_ net87 _0845_ _0140_ _0366_ net40 sg13g2_a221oi_1
XFILLER_20_158 VPWR VGND sg13g2_decap_8
X_2537_ net447 VGND VPWR _0483_ state\[99\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2468_ net369 VGND VPWR _0414_ state\[30\] clknet_leaf_14_clk sg13g2_dfrbpq_1
X_1419_ VPWR _0151_ daisychain\[120\] VGND sg13g2_inv_1
X_2399_ net310 VGND VPWR _0345_ daisychain\[89\] clknet_leaf_8_clk sg13g2_dfrbpq_1
XFILLER_29_715 VPWR VGND sg13g2_fill_2
XFILLER_28_214 VPWR VGND sg13g2_decap_8
XFILLER_25_910 VPWR VGND sg13g2_fill_1
XFILLER_43_217 VPWR VGND sg13g2_decap_8
XFILLER_36_280 VPWR VGND sg13g2_decap_8
XFILLER_25_998 VPWR VGND sg13g2_decap_4
XFILLER_24_464 VPWR VGND sg13g2_decap_4
XFILLER_11_158 VPWR VGND sg13g2_decap_8
XFILLER_22_32 VPWR VGND sg13g2_decap_8
XFILLER_4_825 VPWR VGND sg13g2_decap_8
XFILLER_4_847 VPWR VGND sg13g2_fill_1
XFILLER_3_368 VPWR VGND sg13g2_decap_8
Xfanout182 net192 net182 VPWR VGND sg13g2_buf_1
Xfanout171 net192 net171 VPWR VGND sg13g2_buf_1
Xfanout160 net162 net160 VPWR VGND sg13g2_buf_1
XFILLER_47_523 VPWR VGND sg13g2_decap_8
XFILLER_19_214 VPWR VGND sg13g2_decap_8
Xfanout193 net196 net193 VPWR VGND sg13g2_buf_1
XFILLER_47_84 VPWR VGND sg13g2_decap_8
XFILLER_34_228 VPWR VGND sg13g2_decap_8
XFILLER_27_280 VPWR VGND sg13g2_decap_8
XFILLER_15_442 VPWR VGND sg13g2_decap_8
XFILLER_42_294 VPWR VGND sg13g2_decap_8
X_1770_ net227 VPWR _0685_ VGND state\[57\] net199 sg13g2_o21ai_1
XFILLER_8_67 VPWR VGND sg13g2_decap_8
XFILLER_7_630 VPWR VGND sg13g2_fill_2
XFILLER_6_151 VPWR VGND sg13g2_decap_8
X_2322_ net464 VGND VPWR _0268_ daisychain\[12\] clknet_leaf_16_clk sg13g2_dfrbpq_1
XFILLER_2_390 VPWR VGND sg13g2_decap_8
X_2253_ VGND VPWR _0812_ _0997_ _0483_ net92 sg13g2_a21oi_1
X_2184_ _0963_ net159 state\[65\] VPWR VGND sg13g2_nand2_1
XFILLER_25_228 VPWR VGND sg13g2_decap_8
XFILLER_18_291 VPWR VGND sg13g2_decap_8
X_1968_ VGND VPWR net134 daisychain\[105\] _0834_ net41 sg13g2_a21oi_1
X_1899_ net201 _0243_ _0781_ _0782_ VPWR VGND sg13g2_a21o_1
XFILLER_49_1019 VPWR VGND sg13g2_decap_8
XFILLER_29_534 VPWR VGND sg13g2_decap_4
XFILLER_17_21 VPWR VGND sg13g2_decap_8
XFILLER_16_228 VPWR VGND sg13g2_decap_8
XFILLER_17_98 VPWR VGND sg13g2_decap_8
XFILLER_25_773 VPWR VGND sg13g2_fill_2
XFILLER_12_445 VPWR VGND sg13g2_decap_8
X_2412__285 VPWR VGND net284 sg13g2_tiehi
XFILLER_33_53 VPWR VGND sg13g2_decap_8
XFILLER_8_438 VPWR VGND sg13g2_decap_8
XFILLER_4_622 VPWR VGND sg13g2_fill_1
XFILLER_3_165 VPWR VGND sg13g2_decap_8
XFILLER_0_872 VPWR VGND sg13g2_fill_1
XFILLER_48_843 VPWR VGND sg13g2_fill_2
XFILLER_47_364 VPWR VGND sg13g2_decap_8
XFILLER_43_570 VPWR VGND sg13g2_decap_8
X_1822_ net232 VPWR _0724_ VGND state\[70\] net205 sg13g2_o21ai_1
XFILLER_30_242 VPWR VGND sg13g2_decap_8
X_1753_ VPWR VGND _0672_ net102 _0671_ _0203_ _0308_ net54 sg13g2_a221oi_1
X_1684_ VGND VPWR net125 daisychain\[34\] _0621_ net28 sg13g2_a21oi_1
XFILLER_7_493 VPWR VGND sg13g2_decap_8
X_2305_ VGND VPWR _0890_ _1023_ _0509_ net72 sg13g2_a21oi_1
X_2236_ _0989_ net156 state\[91\] VPWR VGND sg13g2_nand2_1
XFILLER_38_364 VPWR VGND sg13g2_decap_8
X_2167_ VGND VPWR _0683_ _0954_ _0440_ net104 sg13g2_a21oi_1
XFILLER_26_526 VPWR VGND sg13g2_fill_1
X_2098_ _0920_ net124 state\[22\] VPWR VGND sg13g2_nand2_1
XFILLER_22_721 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_494 VPWR VGND uio_oe[5] sg13g2_tiehi
XFILLER_21_242 VPWR VGND sg13g2_decap_8
XFILLER_0_168 VPWR VGND sg13g2_decap_8
XFILLER_28_53 VPWR VGND sg13g2_decap_8
XFILLER_44_301 VPWR VGND sg13g2_decap_8
XFILLER_44_378 VPWR VGND sg13g2_decap_8
XFILLER_44_63 VPWR VGND sg13g2_decap_8
XFILLER_12_242 VPWR VGND sg13g2_decap_8
X_2314__481 VPWR VGND net480 sg13g2_tiehi
XFILLER_8_235 VPWR VGND sg13g2_decap_8
X_2345__419 VPWR VGND net418 sg13g2_tiehi
XFILLER_5_964 VPWR VGND sg13g2_fill_1
XFILLER_5_46 VPWR VGND sg13g2_decap_8
XFILLER_4_496 VPWR VGND sg13g2_decap_8
XFILLER_0_691 VPWR VGND sg13g2_fill_2
X_2021_ VPWR VGND _0873_ net89 _0872_ _0149_ _0375_ net43 sg13g2_a221oi_1
XFILLER_48_684 VPWR VGND sg13g2_decap_4
XFILLER_47_161 VPWR VGND sg13g2_decap_8
XFILLER_35_301 VPWR VGND sg13g2_decap_8
X_1805_ VPWR VGND _0711_ net111 _0710_ _0217_ _0321_ net65 sg13g2_a221oi_1
X_1736_ VGND VPWR net149 daisychain\[47\] _0660_ net53 sg13g2_a21oi_1
X_1667_ net193 _0180_ _0607_ _0608_ VPWR VGND sg13g2_a21o_1
X_1598_ net211 VPWR _0556_ VGND state\[14\] net168 sg13g2_o21ai_1
X_2396__317 VPWR VGND net316 sg13g2_tiehi
X_2219_ VGND VPWR _0761_ _0980_ _0466_ net107 sg13g2_a21oi_1
XFILLER_38_161 VPWR VGND sg13g2_decap_8
XFILLER_26_312 VPWR VGND sg13g2_decap_8
XANTENNA_108 VPWR VGND daisychain\[27\] sg13g2_antennanp
XANTENNA_119 VPWR VGND _0185_ sg13g2_antennanp
XFILLER_27_868 VPWR VGND sg13g2_fill_1
XFILLER_27_857 VPWR VGND sg13g2_fill_2
XFILLER_41_315 VPWR VGND sg13g2_decap_8
XFILLER_14_11 VPWR VGND sg13g2_decap_8
XFILLER_14_88 VPWR VGND sg13g2_decap_8
XFILLER_30_32 VPWR VGND sg13g2_decap_8
XFILLER_5_249 VPWR VGND sg13g2_decap_8
XFILLER_2_967 VPWR VGND sg13g2_fill_1
XFILLER_1_455 VPWR VGND sg13g2_decap_8
XFILLER_39_63 VPWR VGND sg13g2_decap_8
XFILLER_49_459 VPWR VGND sg13g2_decap_8
XFILLER_29_172 VPWR VGND sg13g2_decap_8
XFILLER_17_301 VPWR VGND sg13g2_decap_8
XFILLER_44_175 VPWR VGND sg13g2_decap_8
XFILLER_32_326 VPWR VGND sg13g2_decap_8
XFILLER_9_544 VPWR VGND sg13g2_fill_1
XFILLER_9_577 VPWR VGND sg13g2_decap_8
X_1521_ VPWR _0165_ daisychain\[18\] VGND sg13g2_inv_1
X_1452_ VPWR _0241_ daisychain\[87\] VGND sg13g2_inv_1
X_1383_ VPWR _0048_ state\[28\] VGND sg13g2_inv_1
XFILLER_49_971 VPWR VGND sg13g2_fill_1
X_2004_ VGND VPWR net130 daisychain\[114\] _0861_ net37 sg13g2_a21oi_1
XFILLER_24_816 VPWR VGND sg13g2_decap_8
XFILLER_35_175 VPWR VGND sg13g2_decap_8
XFILLER_23_326 VPWR VGND sg13g2_decap_8
X_2837_ state\[127\] net15 VPWR VGND sg13g2_buf_1
X_1719_ net173 _0194_ _0646_ _0647_ VPWR VGND sg13g2_a21o_1
XFILLER_27_610 VPWR VGND sg13g2_decap_4
XFILLER_18_109 VPWR VGND sg13g2_decap_8
XFILLER_27_687 VPWR VGND sg13g2_decap_4
XFILLER_41_112 VPWR VGND sg13g2_decap_8
XFILLER_26_186 VPWR VGND sg13g2_decap_8
XFILLER_25_32 VPWR VGND sg13g2_decap_8
XFILLER_14_326 VPWR VGND sg13g2_decap_8
XFILLER_41_189 VPWR VGND sg13g2_decap_8
XFILLER_6_503 VPWR VGND sg13g2_decap_8
XFILLER_41_42 VPWR VGND sg13g2_decap_8
X_2561__328 VPWR VGND net327 sg13g2_tiehi
XFILLER_29_1028 VPWR VGND sg13g2_fill_1
XFILLER_1_252 VPWR VGND sg13g2_decap_8
XFILLER_2_25 VPWR VGND sg13g2_decap_8
XFILLER_49_256 VPWR VGND sg13g2_decap_8
XFILLER_37_429 VPWR VGND sg13g2_fill_2
XFILLER_37_418 VPWR VGND sg13g2_decap_8
XFILLER_37_407 VPWR VGND sg13g2_fill_2
XFILLER_45_451 VPWR VGND sg13g2_fill_1
XFILLER_45_440 VPWR VGND sg13g2_decap_4
XFILLER_32_123 VPWR VGND sg13g2_decap_8
XFILLER_17_175 VPWR VGND sg13g2_decap_8
XFILLER_33_668 VPWR VGND sg13g2_fill_1
XFILLER_33_657 VPWR VGND sg13g2_decap_8
XANTENNA_19 VPWR VGND daisychain\[17\] sg13g2_antennanp
XFILLER_9_396 VPWR VGND sg13g2_decap_8
X_2553_ net407 VGND VPWR _0499_ state\[115\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_1504_ VPWR _0184_ daisychain\[35\] VGND sg13g2_inv_1
XFILLER_5_580 VPWR VGND sg13g2_decap_8
X_2484_ net305 VGND VPWR _0430_ state\[46\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1435_ VPWR _0133_ daisychain\[104\] VGND sg13g2_inv_1
X_1366_ VPWR _0067_ state\[45\] VGND sg13g2_inv_1
X_1297_ VPWR _0016_ state\[114\] VGND sg13g2_inv_1
XFILLER_36_495 VPWR VGND sg13g2_fill_1
X_2514__396 VPWR VGND net395 sg13g2_tiehi
XFILLER_24_657 VPWR VGND sg13g2_fill_1
XFILLER_23_123 VPWR VGND sg13g2_decap_8
XFILLER_32_690 VPWR VGND sg13g2_fill_1
XFILLER_11_67 VPWR VGND sg13g2_decap_8
XFILLER_47_727 VPWR VGND sg13g2_fill_2
XFILLER_19_407 VPWR VGND sg13g2_decap_4
XFILLER_46_259 VPWR VGND sg13g2_decap_8
XFILLER_36_42 VPWR VGND sg13g2_decap_8
XFILLER_27_451 VPWR VGND sg13g2_fill_1
XFILLER_42_443 VPWR VGND sg13g2_fill_1
XFILLER_42_432 VPWR VGND sg13g2_decap_8
XFILLER_14_123 VPWR VGND sg13g2_decap_8
XFILLER_10_340 VPWR VGND sg13g2_decap_8
XFILLER_6_333 VPWR VGND sg13g2_decap_8
X_2422__265 VPWR VGND net264 sg13g2_tiehi
XFILLER_35_7 VPWR VGND sg13g2_decap_8
XFILLER_2_572 VPWR VGND sg13g2_decap_8
XFILLER_46_760 VPWR VGND sg13g2_fill_1
XFILLER_37_259 VPWR VGND sg13g2_decap_8
X_1984_ VGND VPWR net134 daisychain\[109\] _0846_ net40 sg13g2_a21oi_1
XFILLER_20_137 VPWR VGND sg13g2_decap_8
XFILLER_9_193 VPWR VGND sg13g2_decap_8
X_2536_ net463 VGND VPWR _0482_ state\[98\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2467_ net373 VGND VPWR _0413_ state\[29\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1418_ VPWR _0152_ daisychain\[121\] VGND sg13g2_inv_1
X_2398_ net312 VGND VPWR _0344_ daisychain\[88\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_1349_ VPWR _0086_ state\[62\] VGND sg13g2_inv_1
XFILLER_24_432 VPWR VGND sg13g2_decap_8
XFILLER_24_476 VPWR VGND sg13g2_fill_1
XFILLER_11_137 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[2\].u.inv1 VPWR digitalenH.g\[2\].u.OUTN net7 VGND sg13g2_inv_1
X_2549__256 VPWR VGND net255 sg13g2_tiehi
XFILLER_7_119 VPWR VGND sg13g2_decap_8
XFILLER_22_11 VPWR VGND sg13g2_decap_8
XFILLER_20_682 VPWR VGND sg13g2_fill_1
XFILLER_22_88 VPWR VGND sg13g2_decap_8
XFILLER_4_859 VPWR VGND sg13g2_decap_8
XFILLER_3_347 VPWR VGND sg13g2_decap_8
Xfanout183 net184 net183 VPWR VGND sg13g2_buf_1
Xfanout172 net174 net172 VPWR VGND sg13g2_buf_1
Xfanout161 net162 net161 VPWR VGND sg13g2_buf_1
Xfanout150 net153 net150 VPWR VGND sg13g2_buf_1
XFILLER_47_502 VPWR VGND sg13g2_fill_2
Xfanout194 net196 net194 VPWR VGND sg13g2_buf_1
XFILLER_47_63 VPWR VGND sg13g2_decap_8
XFILLER_47_546 VPWR VGND sg13g2_decap_8
XFILLER_34_207 VPWR VGND sg13g2_decap_8
XFILLER_15_410 VPWR VGND sg13g2_decap_4
XFILLER_42_273 VPWR VGND sg13g2_decap_8
XFILLER_15_498 VPWR VGND sg13g2_fill_1
XFILLER_8_46 VPWR VGND sg13g2_decap_8
XFILLER_6_130 VPWR VGND sg13g2_decap_8
X_2321_ net466 VGND VPWR _0267_ daisychain\[11\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2252_ _0997_ net139 state\[99\] VPWR VGND sg13g2_nand2_1
X_2324__461 VPWR VGND net460 sg13g2_tiehi
XFILLER_33_4 VPWR VGND sg13g2_decap_8
XFILLER_38_513 VPWR VGND sg13g2_fill_1
X_2183_ VGND VPWR _0707_ _0962_ _0448_ net114 sg13g2_a21oi_1
XFILLER_25_207 VPWR VGND sg13g2_decap_8
XFILLER_18_270 VPWR VGND sg13g2_decap_8
XFILLER_33_284 VPWR VGND sg13g2_decap_8
XFILLER_22_947 VPWR VGND sg13g2_fill_2
XFILLER_21_468 VPWR VGND sg13g2_decap_8
X_1967_ net179 _0135_ _0832_ _0833_ VPWR VGND sg13g2_a21o_1
X_1898_ net229 VPWR _0781_ VGND state\[89\] net201 sg13g2_o21ai_1
X_2519_ net355 VGND VPWR _0465_ state\[81\] clknet_leaf_7_clk sg13g2_dfrbpq_1
XFILLER_17_719 VPWR VGND sg13g2_fill_1
XFILLER_16_207 VPWR VGND sg13g2_decap_8
XFILLER_17_77 VPWR VGND sg13g2_decap_8
XFILLER_12_424 VPWR VGND sg13g2_decap_8
XFILLER_33_32 VPWR VGND sg13g2_decap_8
XFILLER_24_284 VPWR VGND sg13g2_decap_8
XFILLER_8_417 VPWR VGND sg13g2_decap_8
X_2562__264 VPWR VGND net263 sg13g2_tiehi
XFILLER_3_144 VPWR VGND sg13g2_decap_8
XFILLER_0_884 VPWR VGND sg13g2_decap_8
XFILLER_47_343 VPWR VGND sg13g2_decap_8
XFILLER_31_700 VPWR VGND sg13g2_fill_1
XFILLER_30_221 VPWR VGND sg13g2_decap_8
XFILLER_15_284 VPWR VGND sg13g2_decap_8
X_1821_ VPWR VGND _0723_ net112 _0722_ _0221_ _0325_ net66 sg13g2_a221oi_1
XFILLER_30_298 VPWR VGND sg13g2_decap_8
X_1752_ VGND VPWR net149 daisychain\[51\] _0672_ net54 sg13g2_a21oi_1
Xclkbuf_leaf_10_clk clknet_2_3__leaf_clk clknet_leaf_10_clk VPWR VGND sg13g2_buf_8
X_1683_ net170 _0184_ _0619_ _0620_ VPWR VGND sg13g2_a21o_1
XFILLER_7_472 VPWR VGND sg13g2_decap_8
X_2304_ _1023_ net119 state\[125\] VPWR VGND sg13g2_nand2_1
X_2235_ VGND VPWR _0785_ _0988_ _0474_ net108 sg13g2_a21oi_1
X_2166_ _0954_ net151 state\[56\] VPWR VGND sg13g2_nand2_1
XFILLER_38_343 VPWR VGND sg13g2_decap_8
XFILLER_38_398 VPWR VGND sg13g2_decap_4
X_2097_ VGND VPWR _0578_ _0919_ _0405_ net91 sg13g2_a21oi_1
XFILLER_19_590 VPWR VGND sg13g2_decap_4
XFILLER_0_91 VPWR VGND sg13g2_decap_8
XFILLER_21_221 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_495 VPWR VGND uio_oe[6] sg13g2_tiehi
XFILLER_22_766 VPWR VGND sg13g2_fill_1
XFILLER_22_799 VPWR VGND sg13g2_decap_4
XFILLER_21_298 VPWR VGND sg13g2_decap_8
XFILLER_1_637 VPWR VGND sg13g2_decap_8
XFILLER_0_147 VPWR VGND sg13g2_decap_8
XFILLER_28_32 VPWR VGND sg13g2_decap_8
XFILLER_29_354 VPWR VGND sg13g2_decap_8
XFILLER_29_376 VPWR VGND sg13g2_fill_1
XFILLER_45_869 VPWR VGND sg13g2_fill_2
XFILLER_44_357 VPWR VGND sg13g2_decap_8
XFILLER_17_549 VPWR VGND sg13g2_fill_2
XFILLER_44_42 VPWR VGND sg13g2_decap_8
XFILLER_12_221 VPWR VGND sg13g2_decap_8
XFILLER_25_593 VPWR VGND sg13g2_fill_1
XFILLER_13_722 VPWR VGND sg13g2_fill_1
XFILLER_9_715 VPWR VGND sg13g2_fill_2
XFILLER_8_214 VPWR VGND sg13g2_decap_8
XFILLER_40_596 VPWR VGND sg13g2_fill_2
XFILLER_12_298 VPWR VGND sg13g2_decap_8
XFILLER_5_943 VPWR VGND sg13g2_fill_2
XFILLER_5_25 VPWR VGND sg13g2_decap_8
XFILLER_4_431 VPWR VGND sg13g2_decap_8
XFILLER_4_475 VPWR VGND sg13g2_decap_8
XFILLER_0_670 VPWR VGND sg13g2_decap_8
X_2020_ VGND VPWR net136 daisychain\[118\] _0873_ net43 sg13g2_a21oi_1
XFILLER_47_140 VPWR VGND sg13g2_decap_8
XFILLER_35_357 VPWR VGND sg13g2_decap_8
XFILLER_23_519 VPWR VGND sg13g2_fill_1
XFILLER_31_563 VPWR VGND sg13g2_fill_2
XFILLER_31_541 VPWR VGND sg13g2_fill_2
X_1804_ VGND VPWR net159 daisychain\[64\] _0711_ net65 sg13g2_a21oi_1
X_1735_ net195 _0198_ _0658_ _0659_ VPWR VGND sg13g2_a21o_1
XFILLER_7_280 VPWR VGND sg13g2_decap_8
X_1666_ net224 VPWR _0607_ VGND state\[31\] net193 sg13g2_o21ai_1
X_1597_ VPWR VGND _0555_ net75 _0554_ _0160_ _0269_ net29 sg13g2_a221oi_1
XFILLER_27_803 VPWR VGND sg13g2_fill_2
X_2218_ _0980_ net154 state\[82\] VPWR VGND sg13g2_nand2_1
XFILLER_39_685 VPWR VGND sg13g2_fill_2
XFILLER_38_140 VPWR VGND sg13g2_decap_8
XANTENNA_109 VPWR VGND daisychain\[41\] sg13g2_antennanp
X_2149_ VGND VPWR _0656_ _0945_ _0431_ net100 sg13g2_a21oi_1
X_2517__372 VPWR VGND net371 sg13g2_tiehi
XFILLER_26_368 VPWR VGND sg13g2_decap_4
XFILLER_22_541 VPWR VGND sg13g2_fill_1
XFILLER_14_67 VPWR VGND sg13g2_decap_8
XFILLER_5_228 VPWR VGND sg13g2_decap_8
XFILLER_30_11 VPWR VGND sg13g2_decap_8
XFILLER_30_88 VPWR VGND sg13g2_decap_8
XFILLER_2_913 VPWR VGND sg13g2_decap_4
XFILLER_1_434 VPWR VGND sg13g2_decap_8
XFILLER_39_42 VPWR VGND sg13g2_decap_8
XFILLER_2_979 VPWR VGND sg13g2_fill_1
XFILLER_49_438 VPWR VGND sg13g2_decap_8
XFILLER_29_151 VPWR VGND sg13g2_decap_8
XFILLER_45_688 VPWR VGND sg13g2_fill_1
XFILLER_44_154 VPWR VGND sg13g2_decap_8
XFILLER_32_305 VPWR VGND sg13g2_decap_8
XFILLER_17_379 VPWR VGND sg13g2_decap_8
XFILLER_17_357 VPWR VGND sg13g2_decap_8
XFILLER_9_501 VPWR VGND sg13g2_decap_8
XFILLER_13_541 VPWR VGND sg13g2_decap_4
XFILLER_9_523 VPWR VGND sg13g2_decap_8
XFILLER_40_371 VPWR VGND sg13g2_decap_4
X_2529__276 VPWR VGND net275 sg13g2_tiehi
X_1520_ VPWR _0166_ daisychain\[19\] VGND sg13g2_inv_1
X_1451_ VPWR _0242_ daisychain\[88\] VGND sg13g2_inv_1
X_1382_ VPWR _0049_ state\[29\] VGND sg13g2_inv_1
XFILLER_49_950 VPWR VGND sg13g2_fill_2
X_2003_ net176 _0145_ _0859_ _0860_ VPWR VGND sg13g2_a21o_1
XFILLER_35_154 VPWR VGND sg13g2_decap_8
XFILLER_23_305 VPWR VGND sg13g2_decap_8
X_2432__245 VPWR VGND net244 sg13g2_tiehi
X_2836_ state\[126\] net14 VPWR VGND sg13g2_buf_1
X_1718_ net213 VPWR _0646_ VGND state\[44\] net173 sg13g2_o21ai_1
X_1649_ VPWR VGND _0594_ net76 _0593_ _0174_ _0282_ net33 sg13g2_a221oi_1
XFILLER_25_11 VPWR VGND sg13g2_decap_8
XFILLER_26_165 VPWR VGND sg13g2_decap_8
XFILLER_14_305 VPWR VGND sg13g2_decap_8
XFILLER_25_88 VPWR VGND sg13g2_decap_8
XFILLER_41_168 VPWR VGND sg13g2_decap_8
XFILLER_41_21 VPWR VGND sg13g2_decap_8
XFILLER_22_382 VPWR VGND sg13g2_decap_8
XFILLER_41_98 VPWR VGND sg13g2_decap_8
XFILLER_2_776 VPWR VGND sg13g2_fill_1
XFILLER_2_754 VPWR VGND sg13g2_decap_8
XFILLER_1_231 VPWR VGND sg13g2_decap_8
XFILLER_49_235 VPWR VGND sg13g2_decap_8
XFILLER_18_633 VPWR VGND sg13g2_decap_4
XFILLER_46_986 VPWR VGND sg13g2_decap_4
XFILLER_17_154 VPWR VGND sg13g2_decap_8
XFILLER_32_102 VPWR VGND sg13g2_decap_8
XFILLER_32_179 VPWR VGND sg13g2_decap_8
XFILLER_20_319 VPWR VGND sg13g2_decap_8
XFILLER_13_382 VPWR VGND sg13g2_decap_8
XFILLER_41_680 VPWR VGND sg13g2_fill_2
XFILLER_9_375 VPWR VGND sg13g2_fill_2
X_2552_ net439 VGND VPWR _0498_ state\[114\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_1503_ VPWR _0185_ daisychain\[36\] VGND sg13g2_inv_1
X_2483_ net309 VGND VPWR _0429_ state\[45\] clknet_leaf_15_clk sg13g2_dfrbpq_1
X_1434_ VPWR _0134_ daisychain\[105\] VGND sg13g2_inv_1
X_1365_ VPWR _0068_ state\[46\] VGND sg13g2_inv_1
X_1296_ VPWR _0017_ state\[115\] VGND sg13g2_inv_1
XFILLER_23_102 VPWR VGND sg13g2_decap_8
X_2334__441 VPWR VGND net440 sg13g2_tiehi
XFILLER_24_669 VPWR VGND sg13g2_decap_8
XFILLER_11_319 VPWR VGND sg13g2_decap_8
XFILLER_23_179 VPWR VGND sg13g2_decap_8
XFILLER_11_46 VPWR VGND sg13g2_decap_8
XFILLER_3_529 VPWR VGND sg13g2_decap_8
XFILLER_47_706 VPWR VGND sg13g2_fill_1
XFILLER_46_238 VPWR VGND sg13g2_decap_8
XFILLER_36_21 VPWR VGND sg13g2_decap_8
XFILLER_27_463 VPWR VGND sg13g2_decap_8
XFILLER_14_102 VPWR VGND sg13g2_decap_8
XFILLER_36_98 VPWR VGND sg13g2_decap_8
XFILLER_14_179 VPWR VGND sg13g2_decap_8
XFILLER_6_312 VPWR VGND sg13g2_decap_8
XFILLER_6_389 VPWR VGND sg13g2_decap_8
XFILLER_2_551 VPWR VGND sg13g2_decap_8
XFILLER_37_238 VPWR VGND sg13g2_decap_8
XFILLER_33_411 VPWR VGND sg13g2_decap_8
XFILLER_33_477 VPWR VGND sg13g2_fill_2
X_1983_ net179 _0140_ _0844_ _0845_ VPWR VGND sg13g2_a21o_1
XFILLER_20_116 VPWR VGND sg13g2_decap_8
XFILLER_9_172 VPWR VGND sg13g2_decap_8
X_2535_ net479 VGND VPWR _0481_ state\[97\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_2466_ net377 VGND VPWR _0412_ state\[28\] clknet_leaf_17_clk sg13g2_dfrbpq_1
X_1417_ VPWR _0153_ daisychain\[122\] VGND sg13g2_inv_1
X_2397_ net314 VGND VPWR _0343_ daisychain\[87\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_1348_ VPWR _0087_ state\[63\] VGND sg13g2_inv_1
XFILLER_28_249 VPWR VGND sg13g2_decap_8
XFILLER_25_901 VPWR VGND sg13g2_fill_1
XFILLER_25_934 VPWR VGND sg13g2_fill_2
XFILLER_11_116 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[2\].u.inv2 VPWR digitalenH.g\[2\].u.OUTP digitalenH.g\[2\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_22_67 VPWR VGND sg13g2_decap_8
XFILLER_20_672 VPWR VGND sg13g2_fill_1
XFILLER_3_326 VPWR VGND sg13g2_decap_8
Xfanout140 net141 net140 VPWR VGND sg13g2_buf_1
Xfanout173 net174 net173 VPWR VGND sg13g2_buf_1
Xfanout162 net163 net162 VPWR VGND sg13g2_buf_1
Xfanout151 net152 net151 VPWR VGND sg13g2_buf_1
Xfanout195 net196 net195 VPWR VGND sg13g2_buf_1
Xfanout184 net191 net184 VPWR VGND sg13g2_buf_1
XFILLER_47_42 VPWR VGND sg13g2_decap_8
XFILLER_19_249 VPWR VGND sg13g2_decap_8
XFILLER_42_252 VPWR VGND sg13g2_decap_8
XFILLER_8_25 VPWR VGND sg13g2_decap_8
XFILLER_7_632 VPWR VGND sg13g2_fill_1
XFILLER_7_621 VPWR VGND sg13g2_decap_4
XFILLER_10_193 VPWR VGND sg13g2_decap_8
XFILLER_6_186 VPWR VGND sg13g2_decap_8
X_2320_ net468 VGND VPWR _0266_ daisychain\[10\] clknet_leaf_0_clk sg13g2_dfrbpq_1
XFILLER_3_882 VPWR VGND sg13g2_fill_1
X_2251_ VGND VPWR _0809_ _0996_ _0482_ net92 sg13g2_a21oi_1
XFILLER_26_4 VPWR VGND sg13g2_decap_8
X_2182_ _0962_ net159 state\[64\] VPWR VGND sg13g2_nand2_1
XFILLER_33_263 VPWR VGND sg13g2_decap_8
XFILLER_22_937 VPWR VGND sg13g2_decap_8
X_1966_ net216 VPWR _0832_ VGND state\[106\] net177 sg13g2_o21ai_1
X_1897_ VPWR VGND _0780_ net97 _0779_ _0242_ _0344_ net49 sg13g2_a221oi_1
X_2518_ net363 VGND VPWR _0464_ state\[80\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_0_329 VPWR VGND sg13g2_decap_8
X_2449_ net445 VGND VPWR _0395_ state\[11\] clknet_leaf_18_clk sg13g2_dfrbpq_1
XFILLER_29_547 VPWR VGND sg13g2_decap_8
XFILLER_17_56 VPWR VGND sg13g2_decap_8
XFILLER_37_591 VPWR VGND sg13g2_fill_2
XFILLER_12_403 VPWR VGND sg13g2_decap_8
XFILLER_24_263 VPWR VGND sg13g2_decap_8
XFILLER_33_11 VPWR VGND sg13g2_decap_8
XFILLER_33_88 VPWR VGND sg13g2_decap_8
XFILLER_3_123 VPWR VGND sg13g2_decap_8
XFILLER_4_679 VPWR VGND sg13g2_decap_8
XFILLER_0_863 VPWR VGND sg13g2_fill_2
XFILLER_47_322 VPWR VGND sg13g2_decap_8
XFILLER_47_399 VPWR VGND sg13g2_decap_8
XFILLER_30_200 VPWR VGND sg13g2_decap_8
XFILLER_15_263 VPWR VGND sg13g2_decap_8
X_1820_ VGND VPWR net160 daisychain\[68\] _0723_ net66 sg13g2_a21oi_1
XFILLER_30_277 VPWR VGND sg13g2_decap_8
XFILLER_11_480 VPWR VGND sg13g2_decap_8
X_1751_ net193 _0203_ _0670_ _0671_ VPWR VGND sg13g2_a21o_1
XFILLER_7_451 VPWR VGND sg13g2_decap_8
X_1682_ net211 VPWR _0619_ VGND state\[35\] net170 sg13g2_o21ai_1
X_2303_ VGND VPWR _0887_ _1022_ _0508_ net72 sg13g2_a21oi_1
X_2234_ _0988_ net155 state\[90\] VPWR VGND sg13g2_nand2_1
XFILLER_38_322 VPWR VGND sg13g2_decap_8
X_2165_ VGND VPWR _0680_ _0953_ _0439_ net104 sg13g2_a21oi_1
XFILLER_17_0 VPWR VGND sg13g2_decap_8
XFILLER_26_517 VPWR VGND sg13g2_decap_8
XFILLER_0_1023 VPWR VGND sg13g2_decap_4
XFILLER_0_70 VPWR VGND sg13g2_decap_8
X_2096_ _0919_ net138 state\[21\] VPWR VGND sg13g2_nand2_1
XFILLER_34_594 VPWR VGND sg13g2_decap_4
XFILLER_21_200 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_496 VPWR VGND uio_oe[7] sg13g2_tiehi
XFILLER_21_277 VPWR VGND sg13g2_decap_8
X_1949_ VPWR VGND _0819_ net96 _0818_ _0130_ _0357_ net48 sg13g2_a221oi_1
XFILLER_1_616 VPWR VGND sg13g2_decap_8
XFILLER_0_126 VPWR VGND sg13g2_decap_8
XFILLER_48_119 VPWR VGND sg13g2_decap_8
XFILLER_28_11 VPWR VGND sg13g2_decap_8
XFILLER_29_333 VPWR VGND sg13g2_decap_8
XFILLER_45_826 VPWR VGND sg13g2_fill_2
XFILLER_28_88 VPWR VGND sg13g2_decap_8
XFILLER_45_859 VPWR VGND sg13g2_fill_1
XFILLER_44_336 VPWR VGND sg13g2_decap_8
XFILLER_44_21 VPWR VGND sg13g2_decap_8
XFILLER_25_550 VPWR VGND sg13g2_fill_1
XFILLER_12_200 VPWR VGND sg13g2_decap_8
XFILLER_44_98 VPWR VGND sg13g2_decap_8
XFILLER_12_277 VPWR VGND sg13g2_decap_8
XFILLER_5_922 VPWR VGND sg13g2_fill_1
XFILLER_5_955 VPWR VGND sg13g2_fill_2
XFILLER_4_410 VPWR VGND sg13g2_decap_8
XFILLER_4_454 VPWR VGND sg13g2_decap_8
XFILLER_48_620 VPWR VGND sg13g2_fill_2
XFILLER_39_119 VPWR VGND sg13g2_decap_8
XFILLER_47_196 VPWR VGND sg13g2_decap_8
XFILLER_35_336 VPWR VGND sg13g2_decap_8
XFILLER_43_391 VPWR VGND sg13g2_decap_8
X_1803_ net207 _0217_ _0709_ _0710_ VPWR VGND sg13g2_a21o_1
XFILLER_31_597 VPWR VGND sg13g2_fill_2
X_1734_ net224 VPWR _0658_ VGND state\[48\] net194 sg13g2_o21ai_1
X_1665_ VPWR VGND _0606_ net100 _0605_ _0179_ _0286_ net55 sg13g2_a221oi_1
X_1596_ VGND VPWR net122 daisychain\[12\] _0555_ net29 sg13g2_a21oi_1
X_2217_ VGND VPWR _0758_ _0979_ _0465_ net93 sg13g2_a21oi_1
X_2148_ _0945_ net147 state\[47\] VPWR VGND sg13g2_nand2_1
XFILLER_38_196 VPWR VGND sg13g2_decap_8
XFILLER_26_347 VPWR VGND sg13g2_decap_8
X_2079_ VGND VPWR _0551_ _0910_ _0396_ net75 sg13g2_a21oi_1
XFILLER_10_715 VPWR VGND sg13g2_fill_2
XFILLER_14_46 VPWR VGND sg13g2_decap_8
XFILLER_5_207 VPWR VGND sg13g2_decap_8
X_2344__421 VPWR VGND net420 sg13g2_tiehi
XFILLER_30_67 VPWR VGND sg13g2_decap_8
XFILLER_2_958 VPWR VGND sg13g2_fill_2
XFILLER_1_413 VPWR VGND sg13g2_decap_8
XFILLER_39_21 VPWR VGND sg13g2_decap_8
XFILLER_49_417 VPWR VGND sg13g2_decap_8
XFILLER_39_98 VPWR VGND sg13g2_decap_8
XFILLER_29_130 VPWR VGND sg13g2_decap_8
XFILLER_17_336 VPWR VGND sg13g2_decap_8
XFILLER_44_133 VPWR VGND sg13g2_decap_8
XFILLER_40_350 VPWR VGND sg13g2_decap_8
XFILLER_5_763 VPWR VGND sg13g2_fill_1
X_1450_ VPWR _0243_ daisychain\[89\] VGND sg13g2_inv_1
XFILLER_4_284 VPWR VGND sg13g2_decap_8
X_1381_ VPWR _0051_ state\[30\] VGND sg13g2_inv_1
XFILLER_0_490 VPWR VGND sg13g2_decap_8
XFILLER_49_962 VPWR VGND sg13g2_fill_2
XFILLER_48_450 VPWR VGND sg13g2_decap_8
X_2002_ net215 VPWR _0859_ VGND state\[115\] net175 sg13g2_o21ai_1
XFILLER_36_667 VPWR VGND sg13g2_fill_1
XFILLER_35_133 VPWR VGND sg13g2_decap_8
XFILLER_31_361 VPWR VGND sg13g2_decap_8
X_2835_ state\[125\] net13 VPWR VGND sg13g2_buf_1
XFILLER_31_372 VPWR VGND sg13g2_fill_1
X_1717_ VPWR VGND _0645_ net77 _0644_ _0193_ _0299_ net31 sg13g2_a221oi_1
X_1648_ VGND VPWR net123 daisychain\[25\] _0594_ net30 sg13g2_a21oi_1
X_1579_ net165 _0255_ _0541_ _0542_ VPWR VGND sg13g2_a21o_1
XFILLER_27_645 VPWR VGND sg13g2_fill_1
XFILLER_26_144 VPWR VGND sg13g2_decap_8
XFILLER_41_147 VPWR VGND sg13g2_decap_8
XFILLER_25_67 VPWR VGND sg13g2_decap_8
XFILLER_22_361 VPWR VGND sg13g2_decap_8
XFILLER_6_549 VPWR VGND sg13g2_fill_1
XFILLER_6_538 VPWR VGND sg13g2_decap_8
XFILLER_41_77 VPWR VGND sg13g2_decap_8
XFILLER_2_722 VPWR VGND sg13g2_decap_8
XFILLER_29_1019 VPWR VGND sg13g2_decap_8
XFILLER_1_210 VPWR VGND sg13g2_decap_8
XFILLER_49_214 VPWR VGND sg13g2_decap_8
XFILLER_1_287 VPWR VGND sg13g2_decap_8
XFILLER_45_420 VPWR VGND sg13g2_fill_2
XFILLER_17_133 VPWR VGND sg13g2_decap_8
XFILLER_13_361 VPWR VGND sg13g2_decap_8
XFILLER_32_158 VPWR VGND sg13g2_decap_8
XFILLER_9_354 VPWR VGND sg13g2_decap_8
X_2551_ net471 VGND VPWR _0497_ state\[113\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2482_ net313 VGND VPWR _0428_ state\[44\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_1502_ VPWR _0186_ daisychain\[37\] VGND sg13g2_inv_1
X_1433_ VPWR _0135_ daisychain\[106\] VGND sg13g2_inv_1
X_1364_ VPWR _0069_ state\[47\] VGND sg13g2_inv_1
X_1295_ VPWR _0018_ state\[116\] VGND sg13g2_inv_1
XFILLER_48_280 VPWR VGND sg13g2_decap_8
XFILLER_36_442 VPWR VGND sg13g2_decap_8
XFILLER_23_158 VPWR VGND sg13g2_decap_8
XFILLER_11_25 VPWR VGND sg13g2_decap_8
XFILLER_3_508 VPWR VGND sg13g2_decap_8
XFILLER_47_718 VPWR VGND sg13g2_fill_2
XFILLER_46_217 VPWR VGND sg13g2_decap_8
XFILLER_39_280 VPWR VGND sg13g2_decap_8
XFILLER_27_442 VPWR VGND sg13g2_fill_1
XFILLER_36_77 VPWR VGND sg13g2_decap_8
XFILLER_27_486 VPWR VGND sg13g2_decap_8
XFILLER_27_497 VPWR VGND sg13g2_fill_2
XFILLER_14_158 VPWR VGND sg13g2_decap_8
XFILLER_10_375 VPWR VGND sg13g2_decap_8
XFILLER_6_368 VPWR VGND sg13g2_decap_8
XFILLER_2_530 VPWR VGND sg13g2_decap_8
XFILLER_37_217 VPWR VGND sg13g2_decap_8
XFILLER_18_475 VPWR VGND sg13g2_decap_4
XFILLER_45_294 VPWR VGND sg13g2_decap_8
XFILLER_33_423 VPWR VGND sg13g2_decap_4
X_1982_ net217 VPWR _0844_ VGND state\[110\] net181 sg13g2_o21ai_1
XFILLER_14_681 VPWR VGND sg13g2_fill_2
XFILLER_9_151 VPWR VGND sg13g2_decap_8
X_2544__336 VPWR VGND net335 sg13g2_tiehi
X_2534_ net235 VGND VPWR _0480_ state\[96\] clknet_leaf_6_clk sg13g2_dfrbpq_1
XFILLER_47_0 VPWR VGND sg13g2_decap_8
X_2401__307 VPWR VGND net306 sg13g2_tiehi
X_2465_ net381 VGND VPWR _0411_ state\[27\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_2396_ net316 VGND VPWR _0342_ daisychain\[86\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_1416_ VPWR _0154_ daisychain\[123\] VGND sg13g2_inv_1
X_1347_ VPWR _0088_ state\[64\] VGND sg13g2_inv_1
XFILLER_3_81 VPWR VGND sg13g2_decap_8
XFILLER_28_228 VPWR VGND sg13g2_decap_8
XFILLER_36_294 VPWR VGND sg13g2_decap_8
XFILLER_24_489 VPWR VGND sg13g2_decap_8
XFILLER_22_46 VPWR VGND sg13g2_decap_8
XFILLER_20_695 VPWR VGND sg13g2_fill_1
XFILLER_3_305 VPWR VGND sg13g2_decap_8
Xfanout130 net133 net130 VPWR VGND sg13g2_buf_1
Xfanout174 net192 net174 VPWR VGND sg13g2_buf_1
Xfanout163 _1026_ net163 VPWR VGND sg13g2_buf_1
Xfanout152 net153 net152 VPWR VGND sg13g2_buf_1
Xfanout141 net146 net141 VPWR VGND sg13g2_buf_1
XFILLER_47_21 VPWR VGND sg13g2_decap_8
Xfanout196 net200 net196 VPWR VGND sg13g2_buf_1
Xfanout185 net191 net185 VPWR VGND sg13g2_buf_1
XFILLER_19_228 VPWR VGND sg13g2_decap_8
XFILLER_47_98 VPWR VGND sg13g2_decap_8
XFILLER_27_294 VPWR VGND sg13g2_decap_8
XFILLER_15_423 VPWR VGND sg13g2_fill_1
XFILLER_42_231 VPWR VGND sg13g2_decap_8
XFILLER_15_489 VPWR VGND sg13g2_decap_8
XFILLER_10_172 VPWR VGND sg13g2_decap_8
XFILLER_7_699 VPWR VGND sg13g2_decap_4
XFILLER_6_165 VPWR VGND sg13g2_decap_8
XFILLER_40_7 VPWR VGND sg13g2_decap_8
X_2250_ _0996_ net139 state\[98\] VPWR VGND sg13g2_nand2_1
X_2539__416 VPWR VGND net415 sg13g2_tiehi
XFILLER_2_382 VPWR VGND sg13g2_decap_4
X_2181_ VGND VPWR _0704_ _0961_ _0447_ net105 sg13g2_a21oi_1
XFILLER_19_4 VPWR VGND sg13g2_decap_8
XFILLER_33_242 VPWR VGND sg13g2_decap_8
X_1965_ VPWR VGND _0831_ net87 _0830_ _0134_ _0361_ net41 sg13g2_a221oi_1
X_1896_ VGND VPWR net144 daisychain\[87\] _0780_ net49 sg13g2_a21oi_1
XFILLER_0_308 VPWR VGND sg13g2_decap_8
X_2517_ net371 VGND VPWR _0463_ state\[79\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2448_ net449 VGND VPWR _0394_ state\[10\] clknet_leaf_18_clk sg13g2_dfrbpq_1
XFILLER_29_504 VPWR VGND sg13g2_fill_1
X_2379_ net350 VGND VPWR _0325_ daisychain\[69\] clknet_leaf_10_clk sg13g2_dfrbpq_1
XFILLER_29_515 VPWR VGND sg13g2_decap_4
XFILLER_44_518 VPWR VGND sg13g2_fill_1
XFILLER_37_570 VPWR VGND sg13g2_fill_2
XFILLER_17_35 VPWR VGND sg13g2_decap_8
XFILLER_25_743 VPWR VGND sg13g2_decap_8
XFILLER_25_754 VPWR VGND sg13g2_fill_1
XFILLER_24_242 VPWR VGND sg13g2_decap_8
XFILLER_12_459 VPWR VGND sg13g2_decap_8
XFILLER_33_67 VPWR VGND sg13g2_decap_8
XFILLER_3_102 VPWR VGND sg13g2_decap_8
XFILLER_3_179 VPWR VGND sg13g2_decap_8
XFILLER_47_301 VPWR VGND sg13g2_decap_8
X_2354__401 VPWR VGND net400 sg13g2_tiehi
XFILLER_47_378 VPWR VGND sg13g2_decap_8
XFILLER_16_710 VPWR VGND sg13g2_fill_1
XFILLER_43_540 VPWR VGND sg13g2_decap_4
XFILLER_15_242 VPWR VGND sg13g2_decap_8
X_1750_ net225 VPWR _0670_ VGND state\[52\] net193 sg13g2_o21ai_1
XFILLER_30_256 VPWR VGND sg13g2_decap_8
XFILLER_7_430 VPWR VGND sg13g2_decap_8
X_1681_ VPWR VGND _0618_ net79 _0617_ _0183_ _0290_ net30 sg13g2_a221oi_1
X_2302_ _1022_ net116 state\[124\] VPWR VGND sg13g2_nand2_1
X_2233_ VGND VPWR _0782_ _0987_ _0473_ net107 sg13g2_a21oi_1
XFILLER_38_301 VPWR VGND sg13g2_decap_8
X_2164_ _0953_ net151 state\[55\] VPWR VGND sg13g2_nand2_1
XFILLER_38_389 VPWR VGND sg13g2_decap_4
X_2095_ VGND VPWR _0575_ _0918_ _0404_ net91 sg13g2_a21oi_1
XFILLER_21_256 VPWR VGND sg13g2_decap_8
X_1948_ VGND VPWR net142 daisychain\[100\] _0819_ net48 sg13g2_a21oi_1
X_1879_ net189 _0238_ _0766_ _0767_ VPWR VGND sg13g2_a21o_1
XFILLER_0_105 VPWR VGND sg13g2_decap_8
XFILLER_29_312 VPWR VGND sg13g2_decap_8
XFILLER_28_67 VPWR VGND sg13g2_decap_8
XFILLER_44_315 VPWR VGND sg13g2_decap_8
XFILLER_44_77 VPWR VGND sg13g2_decap_8
XFILLER_12_256 VPWR VGND sg13g2_decap_8
XFILLER_8_249 VPWR VGND sg13g2_decap_8
Xclkbuf_2_3__f_clk clknet_2_3__leaf_clk clknet_0_clk VPWR VGND sg13g2_buf_16
XFILLER_47_175 VPWR VGND sg13g2_decap_8
XFILLER_35_315 VPWR VGND sg13g2_decap_8
XFILLER_16_551 VPWR VGND sg13g2_fill_1
XFILLER_44_893 VPWR VGND sg13g2_fill_1
XFILLER_31_532 VPWR VGND sg13g2_fill_1
X_1802_ net231 VPWR _0709_ VGND state\[65\] net207 sg13g2_o21ai_1
X_1733_ VPWR VGND _0657_ net102 _0656_ _0197_ _0303_ net53 sg13g2_a221oi_1
X_1664_ VGND VPWR net147 daisychain\[29\] _0606_ net55 sg13g2_a21oi_1
X_1595_ net168 _0160_ _0553_ _0554_ VPWR VGND sg13g2_a21o_1
XFILLER_39_610 VPWR VGND sg13g2_fill_1
X_2216_ _0979_ net140 state\[81\] VPWR VGND sg13g2_nand2_1
XFILLER_27_805 VPWR VGND sg13g2_fill_1
X_2147_ VGND VPWR _0653_ _0944_ _0430_ net77 sg13g2_a21oi_1
XFILLER_38_175 VPWR VGND sg13g2_decap_8
XFILLER_26_326 VPWR VGND sg13g2_decap_8
X_2078_ _0910_ net122 state\[12\] VPWR VGND sg13g2_nand2_1
XFILLER_41_329 VPWR VGND sg13g2_decap_8
XFILLER_22_510 VPWR VGND sg13g2_decap_8
XFILLER_22_532 VPWR VGND sg13g2_fill_1
XFILLER_14_25 VPWR VGND sg13g2_decap_8
XFILLER_30_46 VPWR VGND sg13g2_decap_8
XFILLER_1_469 VPWR VGND sg13g2_decap_8
XFILLER_39_77 VPWR VGND sg13g2_decap_8
XFILLER_45_624 VPWR VGND sg13g2_decap_8
XFILLER_44_112 VPWR VGND sg13g2_decap_8
XFILLER_29_186 VPWR VGND sg13g2_decap_8
XFILLER_17_315 VPWR VGND sg13g2_decap_8
XFILLER_44_189 VPWR VGND sg13g2_decap_8
XFILLER_9_558 VPWR VGND sg13g2_decap_8
XFILLER_40_395 VPWR VGND sg13g2_fill_1
XFILLER_5_731 VPWR VGND sg13g2_decap_8
XFILLER_4_263 VPWR VGND sg13g2_decap_8
X_1380_ VPWR _0052_ state\[31\] VGND sg13g2_inv_1
X_2001_ VPWR VGND _0858_ net83 _0857_ _0144_ _0370_ net37 sg13g2_a221oi_1
XFILLER_35_112 VPWR VGND sg13g2_decap_8
XFILLER_35_189 VPWR VGND sg13g2_decap_8
XFILLER_31_340 VPWR VGND sg13g2_decap_8
X_2834_ state\[124\] net12 VPWR VGND sg13g2_buf_1
X_1716_ VGND VPWR net125 daisychain\[42\] _0645_ net31 sg13g2_a21oi_1
X_1647_ net174 _0174_ _0592_ _0593_ VPWR VGND sg13g2_a21o_1
XFILLER_6_81 VPWR VGND sg13g2_decap_8
X_1578_ net209 VPWR _0541_ VGND state\[9\] net165 sg13g2_o21ai_1
XFILLER_39_495 VPWR VGND sg13g2_decap_8
XFILLER_26_123 VPWR VGND sg13g2_decap_8
XFILLER_42_627 VPWR VGND sg13g2_decap_4
XFILLER_42_616 VPWR VGND sg13g2_decap_4
XFILLER_42_649 VPWR VGND sg13g2_decap_8
XFILLER_41_126 VPWR VGND sg13g2_decap_8
XFILLER_25_46 VPWR VGND sg13g2_decap_8
XFILLER_22_340 VPWR VGND sg13g2_decap_8
XFILLER_10_535 VPWR VGND sg13g2_fill_1
X_2311__487 VPWR VGND net486 sg13g2_tiehi
XFILLER_6_517 VPWR VGND sg13g2_decap_8
XFILLER_41_56 VPWR VGND sg13g2_decap_8
XFILLER_2_789 VPWR VGND sg13g2_decap_8
XFILLER_1_266 VPWR VGND sg13g2_decap_8
XFILLER_2_39 VPWR VGND sg13g2_decap_8
XFILLER_18_602 VPWR VGND sg13g2_decap_8
XFILLER_46_944 VPWR VGND sg13g2_fill_2
XFILLER_17_112 VPWR VGND sg13g2_decap_8
XFILLER_33_638 VPWR VGND sg13g2_decap_8
XFILLER_32_137 VPWR VGND sg13g2_decap_8
XFILLER_17_189 VPWR VGND sg13g2_decap_8
XFILLER_13_340 VPWR VGND sg13g2_decap_8
XFILLER_9_333 VPWR VGND sg13g2_decap_8
XFILLER_41_682 VPWR VGND sg13g2_fill_1
XFILLER_9_377 VPWR VGND sg13g2_fill_1
X_2550_ net239 VGND VPWR _0496_ state\[112\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2481_ net317 VGND VPWR _0427_ state\[43\] clknet_leaf_16_clk sg13g2_dfrbpq_1
X_1501_ VPWR _0187_ daisychain\[38\] VGND sg13g2_inv_1
X_1432_ VPWR _0136_ daisychain\[107\] VGND sg13g2_inv_1
XFILLER_49_4 VPWR VGND sg13g2_decap_8
X_2362__385 VPWR VGND net384 sg13g2_tiehi
X_1363_ VPWR _0070_ state\[48\] VGND sg13g2_inv_1
X_1294_ VPWR _0019_ state\[117\] VGND sg13g2_inv_1
XFILLER_49_793 VPWR VGND sg13g2_fill_1
X_2438__489 VPWR VGND net488 sg13g2_tiehi
XFILLER_36_421 VPWR VGND sg13g2_decap_8
XFILLER_23_137 VPWR VGND sg13g2_decap_8
XFILLER_32_671 VPWR VGND sg13g2_fill_1
X_2408__293 VPWR VGND net292 sg13g2_tiehi
XFILLER_36_56 VPWR VGND sg13g2_decap_8
XFILLER_28_999 VPWR VGND sg13g2_fill_2
XFILLER_15_616 VPWR VGND sg13g2_decap_8
XFILLER_14_137 VPWR VGND sg13g2_decap_8
XFILLER_23_693 VPWR VGND sg13g2_fill_2
XFILLER_23_671 VPWR VGND sg13g2_decap_4
XFILLER_10_354 VPWR VGND sg13g2_decap_8
XFILLER_6_347 VPWR VGND sg13g2_decap_8
XFILLER_7_0 VPWR VGND sg13g2_decap_8
XFILLER_2_586 VPWR VGND sg13g2_decap_8
XFILLER_46_796 VPWR VGND sg13g2_fill_2
XFILLER_46_785 VPWR VGND sg13g2_decap_8
XFILLER_45_273 VPWR VGND sg13g2_decap_8
X_1981_ VPWR VGND _0843_ net88 _0842_ _0138_ _0365_ net42 sg13g2_a221oi_1
XFILLER_14_693 VPWR VGND sg13g2_fill_2
XFILLER_9_130 VPWR VGND sg13g2_decap_8
X_2533_ net243 VGND VPWR _0479_ state\[95\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_2464_ net385 VGND VPWR _0410_ state\[26\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2395_ net318 VGND VPWR _0341_ daisychain\[85\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_1415_ VPWR _0155_ daisychain\[124\] VGND sg13g2_inv_1
X_1346_ VPWR _0089_ state\[65\] VGND sg13g2_inv_1
XFILLER_3_60 VPWR VGND sg13g2_decap_8
XFILLER_28_207 VPWR VGND sg13g2_decap_8
XFILLER_49_590 VPWR VGND sg13g2_decap_8
XFILLER_36_273 VPWR VGND sg13g2_decap_8
XFILLER_24_468 VPWR VGND sg13g2_fill_1
XFILLER_24_457 VPWR VGND sg13g2_decap_8
XFILLER_22_25 VPWR VGND sg13g2_decap_8
XFILLER_0_7 VPWR VGND sg13g2_decap_8
Xfanout131 net133 net131 VPWR VGND sg13g2_buf_1
Xfanout120 net128 net120 VPWR VGND sg13g2_buf_1
Xfanout164 net167 net164 VPWR VGND sg13g2_buf_1
Xfanout153 net163 net153 VPWR VGND sg13g2_buf_1
Xfanout142 net145 net142 VPWR VGND sg13g2_buf_1
Xfanout197 net198 net197 VPWR VGND sg13g2_buf_1
Xfanout186 net191 net186 VPWR VGND sg13g2_buf_1
Xfanout175 net176 net175 VPWR VGND sg13g2_buf_1
XFILLER_47_516 VPWR VGND sg13g2_decap_8
XFILLER_19_207 VPWR VGND sg13g2_decap_8
XFILLER_47_77 VPWR VGND sg13g2_decap_8
X_2532__252 VPWR VGND net251 sg13g2_tiehi
XFILLER_42_210 VPWR VGND sg13g2_decap_8
XFILLER_27_273 VPWR VGND sg13g2_decap_8
XFILLER_15_435 VPWR VGND sg13g2_decap_8
XFILLER_42_287 VPWR VGND sg13g2_decap_8
XFILLER_10_151 VPWR VGND sg13g2_decap_8
XFILLER_11_663 VPWR VGND sg13g2_decap_8
XFILLER_11_674 VPWR VGND sg13g2_decap_8
XFILLER_7_656 VPWR VGND sg13g2_fill_1
XFILLER_6_144 VPWR VGND sg13g2_decap_8
XFILLER_2_361 VPWR VGND sg13g2_decap_8
X_2180_ _0961_ net152 state\[63\] VPWR VGND sg13g2_nand2_1
XFILLER_46_560 VPWR VGND sg13g2_fill_2
XFILLER_33_221 VPWR VGND sg13g2_decap_8
XFILLER_18_284 VPWR VGND sg13g2_decap_8
X_1964_ VGND VPWR net142 daisychain\[104\] _0831_ net41 sg13g2_a21oi_1
Xclkbuf_leaf_13_clk clknet_2_2__leaf_clk clknet_leaf_13_clk VPWR VGND sg13g2_buf_8
XFILLER_33_298 VPWR VGND sg13g2_decap_8
X_1895_ net186 _0242_ _0778_ _0779_ VPWR VGND sg13g2_a21o_1
X_2516_ net379 VGND VPWR _0462_ state\[78\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2447_ net453 VGND VPWR _0393_ state\[9\] clknet_leaf_0_clk sg13g2_dfrbpq_1
X_2378_ net352 VGND VPWR _0324_ daisychain\[68\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_1329_ VPWR _0108_ state\[82\] VGND sg13g2_inv_1
XFILLER_17_14 VPWR VGND sg13g2_decap_8
XFILLER_37_593 VPWR VGND sg13g2_fill_1
XFILLER_25_766 VPWR VGND sg13g2_decap_8
XFILLER_24_221 VPWR VGND sg13g2_decap_8
XFILLER_12_438 VPWR VGND sg13g2_decap_8
XFILLER_33_46 VPWR VGND sg13g2_decap_8
XFILLER_24_298 VPWR VGND sg13g2_decap_8
XFILLER_21_994 VPWR VGND sg13g2_fill_1
XFILLER_3_158 VPWR VGND sg13g2_decap_8
XFILLER_0_821 VPWR VGND sg13g2_decap_8
XFILLER_0_898 VPWR VGND sg13g2_fill_2
XFILLER_47_357 VPWR VGND sg13g2_decap_8
XFILLER_15_221 VPWR VGND sg13g2_decap_8
XFILLER_43_596 VPWR VGND sg13g2_decap_8
XFILLER_43_563 VPWR VGND sg13g2_decap_8
XFILLER_30_235 VPWR VGND sg13g2_decap_8
XFILLER_15_298 VPWR VGND sg13g2_decap_8
X_1680_ VGND VPWR net124 daisychain\[33\] _0618_ net33 sg13g2_a21oi_1
XFILLER_7_486 VPWR VGND sg13g2_decap_8
X_2301_ VGND VPWR _0884_ _1021_ _0507_ net72 sg13g2_a21oi_1
XFILLER_31_4 VPWR VGND sg13g2_decap_8
X_2232_ _0987_ net154 state\[89\] VPWR VGND sg13g2_nand2_1
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk clknet_leaf_2_clk VPWR VGND sg13g2_buf_8
X_2163_ VGND VPWR _0677_ _0952_ _0438_ net104 sg13g2_a21oi_1
XFILLER_38_357 VPWR VGND sg13g2_decap_8
X_2094_ _0918_ net138 state\[20\] VPWR VGND sg13g2_nand2_1
XFILLER_21_235 VPWR VGND sg13g2_decap_8
XFILLER_9_81 VPWR VGND sg13g2_decap_8
X_1947_ net187 _0130_ _0817_ _0818_ VPWR VGND sg13g2_a21o_1
X_1878_ net220 VPWR _0766_ VGND state\[84\] net189 sg13g2_o21ai_1
XFILLER_28_46 VPWR VGND sg13g2_decap_8
XFILLER_45_828 VPWR VGND sg13g2_fill_1
XFILLER_29_368 VPWR VGND sg13g2_fill_2
XFILLER_17_519 VPWR VGND sg13g2_fill_2
XFILLER_44_56 VPWR VGND sg13g2_decap_8
XFILLER_12_235 VPWR VGND sg13g2_decap_8
XFILLER_40_544 VPWR VGND sg13g2_fill_2
XFILLER_8_228 VPWR VGND sg13g2_decap_8
XFILLER_5_913 VPWR VGND sg13g2_fill_2
XFILLER_5_902 VPWR VGND sg13g2_decap_4
XFILLER_5_935 VPWR VGND sg13g2_fill_1
XFILLER_5_39 VPWR VGND sg13g2_decap_8
XFILLER_4_445 VPWR VGND sg13g2_decap_4
XFILLER_4_489 VPWR VGND sg13g2_decap_8
XFILLER_0_651 VPWR VGND sg13g2_decap_8
XFILLER_0_684 VPWR VGND sg13g2_decap_8
X_2321__467 VPWR VGND net466 sg13g2_tiehi
XFILLER_48_622 VPWR VGND sg13g2_fill_1
XFILLER_48_688 VPWR VGND sg13g2_fill_1
XFILLER_47_154 VPWR VGND sg13g2_decap_8
XFILLER_43_371 VPWR VGND sg13g2_decap_8
X_1801_ VPWR VGND _0708_ net111 _0707_ _0216_ _0320_ net65 sg13g2_a221oi_1
X_1732_ VGND VPWR net149 daisychain\[46\] _0657_ net53 sg13g2_a21oi_1
X_1663_ net194 _0179_ _0604_ _0605_ VPWR VGND sg13g2_a21o_1
XFILLER_7_294 VPWR VGND sg13g2_decap_8
X_1594_ net211 VPWR _0553_ VGND state\[13\] net168 sg13g2_o21ai_1
X_2215_ VGND VPWR _0755_ _0978_ _0464_ net108 sg13g2_a21oi_1
XFILLER_39_622 VPWR VGND sg13g2_decap_8
XFILLER_38_154 VPWR VGND sg13g2_decap_8
X_2146_ _0944_ net149 state\[46\] VPWR VGND sg13g2_nand2_1
XFILLER_26_305 VPWR VGND sg13g2_decap_8
X_2077_ VGND VPWR _0548_ _0909_ _0395_ net81 sg13g2_a21oi_1
X_2372__365 VPWR VGND net364 sg13g2_tiehi
XFILLER_41_308 VPWR VGND sg13g2_decap_8
XFILLER_34_393 VPWR VGND sg13g2_fill_1
XFILLER_30_25 VPWR VGND sg13g2_decap_8
XFILLER_1_448 VPWR VGND sg13g2_decap_8
XFILLER_39_56 VPWR VGND sg13g2_decap_8
XFILLER_29_165 VPWR VGND sg13g2_decap_8
X_2418__273 VPWR VGND net272 sg13g2_tiehi
XFILLER_44_168 VPWR VGND sg13g2_decap_8
XFILLER_32_319 VPWR VGND sg13g2_decap_8
XFILLER_26_894 VPWR VGND sg13g2_fill_1
XFILLER_9_515 VPWR VGND sg13g2_decap_4
XFILLER_9_537 VPWR VGND sg13g2_decap_8
XFILLER_5_754 VPWR VGND sg13g2_fill_1
XFILLER_4_242 VPWR VGND sg13g2_decap_8
X_2000_ VGND VPWR net130 daisychain\[113\] _0858_ net37 sg13g2_a21oi_1
XFILLER_35_168 VPWR VGND sg13g2_decap_8
XFILLER_23_319 VPWR VGND sg13g2_decap_8
XFILLER_16_382 VPWR VGND sg13g2_decap_8
X_2833_ state\[123\] net11 VPWR VGND sg13g2_buf_1
X_1715_ net172 _0193_ _0643_ _0644_ VPWR VGND sg13g2_a21o_1
XFILLER_6_60 VPWR VGND sg13g2_decap_8
X_1646_ net212 VPWR _0592_ VGND state\[26\] net174 sg13g2_o21ai_1
X_1577_ VPWR VGND _0540_ net71 _0539_ _0244_ _0264_ net25 sg13g2_a221oi_1
XFILLER_26_102 VPWR VGND sg13g2_decap_8
X_2129_ VGND VPWR _0626_ _0935_ _0421_ net73 sg13g2_a21oi_1
XFILLER_41_105 VPWR VGND sg13g2_decap_8
XFILLER_26_179 VPWR VGND sg13g2_decap_8
XFILLER_25_25 VPWR VGND sg13g2_decap_8
XFILLER_14_319 VPWR VGND sg13g2_decap_8
XFILLER_35_691 VPWR VGND sg13g2_fill_1
XFILLER_23_842 VPWR VGND sg13g2_decap_4
XFILLER_41_35 VPWR VGND sg13g2_decap_8
XFILLER_22_396 VPWR VGND sg13g2_fill_2
XFILLER_9_4 VPWR VGND sg13g2_decap_8
XFILLER_1_245 VPWR VGND sg13g2_decap_8
XFILLER_2_18 VPWR VGND sg13g2_decap_8
XFILLER_49_249 VPWR VGND sg13g2_decap_8
XFILLER_46_901 VPWR VGND sg13g2_fill_1
XFILLER_46_912 VPWR VGND sg13g2_fill_2
XFILLER_45_444 VPWR VGND sg13g2_fill_1
XFILLER_45_433 VPWR VGND sg13g2_decap_8
XFILLER_17_168 VPWR VGND sg13g2_decap_8
XFILLER_32_116 VPWR VGND sg13g2_decap_8
XFILLER_9_312 VPWR VGND sg13g2_decap_8
XFILLER_40_182 VPWR VGND sg13g2_decap_8
XFILLER_13_396 VPWR VGND sg13g2_decap_8
XFILLER_9_389 VPWR VGND sg13g2_decap_8
X_2480_ net321 VGND VPWR _0426_ state\[42\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_1500_ VPWR _0188_ daisychain\[39\] VGND sg13g2_inv_1
XFILLER_5_573 VPWR VGND sg13g2_decap_8
X_1431_ VPWR _0137_ daisychain\[108\] VGND sg13g2_inv_1
X_1362_ VPWR _0071_ state\[49\] VGND sg13g2_inv_1
X_1293_ VPWR _0020_ state\[118\] VGND sg13g2_inv_1
XFILLER_36_488 VPWR VGND sg13g2_decap_8
XFILLER_23_116 VPWR VGND sg13g2_decap_8
XFILLER_32_661 VPWR VGND sg13g2_decap_4
XFILLER_31_193 VPWR VGND sg13g2_decap_8
X_1629_ VPWR VGND _0579_ net91 _0578_ _0169_ _0277_ net44 sg13g2_a221oi_1
XFILLER_36_35 VPWR VGND sg13g2_decap_8
XFILLER_14_116 VPWR VGND sg13g2_decap_8
XFILLER_10_333 VPWR VGND sg13g2_decap_8
XFILLER_22_193 VPWR VGND sg13g2_decap_8
XFILLER_6_326 VPWR VGND sg13g2_decap_8
XFILLER_2_565 VPWR VGND sg13g2_decap_8
XFILLER_46_753 VPWR VGND sg13g2_decap_8
XFILLER_18_444 VPWR VGND sg13g2_decap_4
XFILLER_45_252 VPWR VGND sg13g2_decap_8
X_1980_ VGND VPWR net134 daisychain\[108\] _0843_ net42 sg13g2_a21oi_1
XFILLER_14_683 VPWR VGND sg13g2_fill_1
XFILLER_13_193 VPWR VGND sg13g2_decap_8
X_2509__436 VPWR VGND net435 sg13g2_tiehi
XFILLER_9_186 VPWR VGND sg13g2_decap_8
X_2532_ net251 VGND VPWR _0478_ state\[94\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_2463_ net389 VGND VPWR _0409_ state\[25\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2394_ net320 VGND VPWR _0340_ daisychain\[84\] clknet_leaf_6_clk sg13g2_dfrbpq_1
X_1414_ VPWR _0156_ daisychain\[125\] VGND sg13g2_inv_1
X_1345_ VPWR _0090_ state\[66\] VGND sg13g2_inv_1
XFILLER_36_252 VPWR VGND sg13g2_decap_8
XFILLER_25_926 VPWR VGND sg13g2_fill_1
XFILLER_24_425 VPWR VGND sg13g2_decap_8
XFILLER_24_447 VPWR VGND sg13g2_fill_1
Xfanout121 net128 net121 VPWR VGND sg13g2_buf_1
Xfanout110 net115 net110 VPWR VGND sg13g2_buf_1
Xfanout165 net166 net165 VPWR VGND sg13g2_buf_1
Xfanout154 net157 net154 VPWR VGND sg13g2_buf_1
Xfanout143 net145 net143 VPWR VGND sg13g2_buf_1
Xfanout132 net133 net132 VPWR VGND sg13g2_buf_1
Xfanout198 net200 net198 VPWR VGND sg13g2_buf_1
Xfanout187 net190 net187 VPWR VGND sg13g2_buf_1
Xfanout176 net178 net176 VPWR VGND sg13g2_buf_1
XFILLER_47_56 VPWR VGND sg13g2_decap_8
X_2491__278 VPWR VGND net277 sg13g2_tiehi
XFILLER_27_252 VPWR VGND sg13g2_decap_8
XFILLER_15_414 VPWR VGND sg13g2_fill_1
XFILLER_15_403 VPWR VGND sg13g2_decap_8
XFILLER_42_266 VPWR VGND sg13g2_decap_8
XFILLER_8_39 VPWR VGND sg13g2_decap_8
XFILLER_10_130 VPWR VGND sg13g2_decap_8
XFILLER_6_123 VPWR VGND sg13g2_decap_8
XFILLER_12_81 VPWR VGND sg13g2_decap_8
XFILLER_7_668 VPWR VGND sg13g2_fill_2
XFILLER_2_340 VPWR VGND sg13g2_decap_8
XFILLER_46_594 VPWR VGND sg13g2_fill_1
XFILLER_33_200 VPWR VGND sg13g2_decap_8
XFILLER_18_263 VPWR VGND sg13g2_decap_8
XFILLER_33_277 VPWR VGND sg13g2_decap_8
X_1963_ net179 _0134_ _0829_ _0830_ VPWR VGND sg13g2_a21o_1
X_2331__447 VPWR VGND net446 sg13g2_tiehi
X_1894_ net219 VPWR _0778_ VGND state\[88\] net186 sg13g2_o21ai_1
X_2515_ net387 VGND VPWR _0461_ state\[77\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2446_ net457 VGND VPWR _0392_ state\[8\] clknet_leaf_0_clk sg13g2_dfrbpq_1
XFILLER_25_1024 VPWR VGND sg13g2_decap_4
XFILLER_25_1002 VPWR VGND sg13g2_fill_2
X_2377_ net354 VGND VPWR _0323_ daisychain\[67\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_1328_ VPWR _0109_ state\[83\] VGND sg13g2_inv_1
XFILLER_25_723 VPWR VGND sg13g2_fill_1
XFILLER_24_200 VPWR VGND sg13g2_decap_8
XFILLER_12_417 VPWR VGND sg13g2_decap_8
XFILLER_33_25 VPWR VGND sg13g2_decap_8
XFILLER_24_277 VPWR VGND sg13g2_decap_8
XFILLER_20_450 VPWR VGND sg13g2_fill_2
XFILLER_20_494 VPWR VGND sg13g2_decap_8
XFILLER_20_483 VPWR VGND sg13g2_decap_4
X_2382__345 VPWR VGND net344 sg13g2_tiehi
XFILLER_3_137 VPWR VGND sg13g2_decap_8
XFILLER_0_877 VPWR VGND sg13g2_decap_8
XFILLER_47_336 VPWR VGND sg13g2_decap_8
XFILLER_15_200 VPWR VGND sg13g2_decap_8
XFILLER_31_704 VPWR VGND sg13g2_fill_1
XFILLER_15_277 VPWR VGND sg13g2_decap_8
XFILLER_30_214 VPWR VGND sg13g2_decap_8
XFILLER_11_494 VPWR VGND sg13g2_decap_8
X_2428__253 VPWR VGND net252 sg13g2_tiehi
XFILLER_7_465 VPWR VGND sg13g2_decap_8
X_2300_ _1021_ net119 state\[123\] VPWR VGND sg13g2_nand2_1
X_2231_ VGND VPWR _0779_ _0986_ _0472_ net94 sg13g2_a21oi_1
XFILLER_24_4 VPWR VGND sg13g2_decap_8
X_2162_ _0952_ net151 state\[54\] VPWR VGND sg13g2_nand2_1
XFILLER_38_336 VPWR VGND sg13g2_decap_8
X_2093_ VGND VPWR _0572_ _0917_ _0403_ net79 sg13g2_a21oi_1
XFILLER_0_84 VPWR VGND sg13g2_decap_8
XFILLER_34_520 VPWR VGND sg13g2_fill_2
XFILLER_22_715 VPWR VGND sg13g2_fill_2
XFILLER_22_759 VPWR VGND sg13g2_decap_8
XFILLER_21_214 VPWR VGND sg13g2_decap_8
XFILLER_9_60 VPWR VGND sg13g2_decap_8
X_1946_ net220 VPWR _0817_ VGND state\[101\] net187 sg13g2_o21ai_1
X_1877_ VPWR VGND _0765_ net93 _0764_ _0237_ _0339_ net46 sg13g2_a221oi_1
XdigitalenL.g\[0\].u.inv1 VPWR digitalenL.g\[0\].u.OUTN net6 VGND sg13g2_inv_1
X_2429_ net250 VGND VPWR _0375_ daisychain\[119\] clknet_leaf_4_clk sg13g2_dfrbpq_1
XFILLER_28_25 VPWR VGND sg13g2_decap_8
XFILLER_29_347 VPWR VGND sg13g2_decap_8
XFILLER_44_35 VPWR VGND sg13g2_decap_8
XFILLER_40_501 VPWR VGND sg13g2_fill_1
XFILLER_25_586 VPWR VGND sg13g2_decap_8
XFILLER_13_715 VPWR VGND sg13g2_decap_8
XFILLER_12_214 VPWR VGND sg13g2_decap_8
XFILLER_8_207 VPWR VGND sg13g2_decap_8
XFILLER_40_556 VPWR VGND sg13g2_fill_2
XFILLER_40_589 VPWR VGND sg13g2_decap_8
XFILLER_20_291 VPWR VGND sg13g2_decap_8
XFILLER_5_18 VPWR VGND sg13g2_decap_8
XFILLER_4_424 VPWR VGND sg13g2_decap_8
XFILLER_4_468 VPWR VGND sg13g2_decap_8
XFILLER_0_630 VPWR VGND sg13g2_decap_8
XFILLER_47_133 VPWR VGND sg13g2_decap_8
XFILLER_43_350 VPWR VGND sg13g2_decap_8
X_1800_ VGND VPWR net159 daisychain\[63\] _0708_ net65 sg13g2_a21oi_1
XFILLER_11_291 VPWR VGND sg13g2_decap_8
X_1731_ net195 _0197_ _0655_ _0656_ VPWR VGND sg13g2_a21o_1
X_1662_ net224 VPWR _0604_ VGND state\[30\] net194 sg13g2_o21ai_1
XFILLER_7_273 VPWR VGND sg13g2_decap_8
X_1593_ VPWR VGND _0552_ net76 _0551_ _0159_ _0268_ net30 sg13g2_a221oi_1
X_2214_ _0978_ net155 state\[80\] VPWR VGND sg13g2_nand2_1
X_2145_ VGND VPWR _0650_ _0943_ _0429_ net77 sg13g2_a21oi_1
XFILLER_38_133 VPWR VGND sg13g2_decap_8
X_2076_ _0909_ net146 state\[11\] VPWR VGND sg13g2_nand2_1
XFILLER_34_361 VPWR VGND sg13g2_decap_8
XFILLER_22_578 VPWR VGND sg13g2_decap_8
X_1929_ VPWR VGND _0804_ net95 _0803_ _0251_ _0352_ net48 sg13g2_a221oi_1
XFILLER_2_906 VPWR VGND sg13g2_decap_8
XFILLER_2_917 VPWR VGND sg13g2_fill_1
XFILLER_1_427 VPWR VGND sg13g2_decap_8
XFILLER_39_35 VPWR VGND sg13g2_decap_8
XFILLER_45_604 VPWR VGND sg13g2_fill_1
XFILLER_29_144 VPWR VGND sg13g2_decap_8
XFILLER_44_147 VPWR VGND sg13g2_decap_8
XFILLER_25_361 VPWR VGND sg13g2_decap_8
XFILLER_25_372 VPWR VGND sg13g2_fill_2
XFILLER_13_534 VPWR VGND sg13g2_decap_8
XFILLER_9_549 VPWR VGND sg13g2_fill_1
XFILLER_40_364 VPWR VGND sg13g2_decap_8
XFILLER_13_589 VPWR VGND sg13g2_fill_2
XFILLER_4_221 VPWR VGND sg13g2_decap_8
XFILLER_4_298 VPWR VGND sg13g2_decap_8
XFILLER_20_81 VPWR VGND sg13g2_decap_8
XFILLER_1_961 VPWR VGND sg13g2_fill_2
XFILLER_1_994 VPWR VGND sg13g2_fill_2
XFILLER_48_464 VPWR VGND sg13g2_fill_2
XFILLER_48_497 VPWR VGND sg13g2_fill_1
XFILLER_35_147 VPWR VGND sg13g2_decap_8
XFILLER_44_681 VPWR VGND sg13g2_fill_2
XFILLER_16_361 VPWR VGND sg13g2_decap_8
X_2832_ state\[122\] net10 VPWR VGND sg13g2_buf_1
X_1714_ net213 VPWR _0643_ VGND state\[43\] net172 sg13g2_o21ai_1
X_1645_ VPWR VGND _0591_ net93 _0590_ _0173_ _0281_ net45 sg13g2_a221oi_1
X_1576_ VGND VPWR net118 daisychain\[7\] _0540_ net25 sg13g2_a21oi_1
X_2128_ _0935_ net120 state\[37\] VPWR VGND sg13g2_nand2_1
XFILLER_27_659 VPWR VGND sg13g2_fill_1
X_2059_ VGND VPWR _0521_ _0900_ _0386_ net84 sg13g2_a21oi_1
XFILLER_26_158 VPWR VGND sg13g2_decap_8
XFILLER_41_14 VPWR VGND sg13g2_decap_8
XFILLER_22_375 VPWR VGND sg13g2_decap_8
X_2487__294 VPWR VGND net293 sg13g2_tiehi
XFILLER_1_224 VPWR VGND sg13g2_decap_8
XFILLER_49_228 VPWR VGND sg13g2_decap_8
XFILLER_46_979 VPWR VGND sg13g2_decap_8
XFILLER_45_456 VPWR VGND sg13g2_decap_8
XFILLER_17_147 VPWR VGND sg13g2_decap_8
XFILLER_33_629 VPWR VGND sg13g2_decap_4
XFILLER_26_681 VPWR VGND sg13g2_fill_1
XFILLER_26_670 VPWR VGND sg13g2_decap_8
XFILLER_13_375 VPWR VGND sg13g2_decap_8
XFILLER_41_673 VPWR VGND sg13g2_decap_8
XFILLER_40_161 VPWR VGND sg13g2_decap_8
XFILLER_15_81 VPWR VGND sg13g2_decap_8
XFILLER_9_368 VPWR VGND sg13g2_decap_8
X_2466__378 VPWR VGND net377 sg13g2_tiehi
XFILLER_5_552 VPWR VGND sg13g2_decap_8
X_1430_ VPWR _0138_ daisychain\[109\] VGND sg13g2_inv_1
X_1361_ VPWR _0073_ state\[50\] VGND sg13g2_inv_1
X_1292_ VPWR _0021_ state\[119\] VGND sg13g2_inv_1
XFILLER_49_773 VPWR VGND sg13g2_fill_2
XFILLER_48_294 VPWR VGND sg13g2_decap_8
XFILLER_17_670 VPWR VGND sg13g2_decap_8
XFILLER_31_172 VPWR VGND sg13g2_decap_8
XFILLER_11_39 VPWR VGND sg13g2_decap_8
X_1628_ VGND VPWR net138 daisychain\[20\] _0579_ net44 sg13g2_a21oi_1
X_2341__427 VPWR VGND net426 sg13g2_tiehi
X_1559_ net177 _0200_ _0526_ _0527_ VPWR VGND sg13g2_a21o_1
XFILLER_39_294 VPWR VGND sg13g2_decap_8
XFILLER_36_14 VPWR VGND sg13g2_decap_8
XFILLER_27_456 VPWR VGND sg13g2_decap_8
XFILLER_10_312 VPWR VGND sg13g2_decap_8
XFILLER_23_695 VPWR VGND sg13g2_fill_1
XFILLER_22_172 VPWR VGND sg13g2_decap_8
XFILLER_6_305 VPWR VGND sg13g2_decap_8
XFILLER_2_544 VPWR VGND sg13g2_decap_8
X_2392__325 VPWR VGND net324 sg13g2_tiehi
XFILLER_46_743 VPWR VGND sg13g2_decap_4
XFILLER_45_231 VPWR VGND sg13g2_decap_8
XFILLER_20_109 VPWR VGND sg13g2_decap_8
XFILLER_13_172 VPWR VGND sg13g2_decap_8
XFILLER_41_492 VPWR VGND sg13g2_fill_2
XFILLER_9_165 VPWR VGND sg13g2_decap_8
X_2531_ net259 VGND VPWR _0477_ state\[93\] clknet_leaf_8_clk sg13g2_dfrbpq_1
XFILLER_5_382 VPWR VGND sg13g2_decap_8
X_2462_ net393 VGND VPWR _0408_ state\[24\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_2393_ net322 VGND VPWR _0339_ daisychain\[83\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_1413_ VPWR _0157_ daisychain\[126\] VGND sg13g2_inv_1
X_1344_ VPWR _0091_ state\[67\] VGND sg13g2_inv_1
XFILLER_3_95 VPWR VGND sg13g2_decap_8
XFILLER_37_710 VPWR VGND sg13g2_fill_1
XFILLER_36_231 VPWR VGND sg13g2_decap_8
XFILLER_11_109 VPWR VGND sg13g2_decap_8
XFILLER_32_492 VPWR VGND sg13g2_decap_8
XFILLER_20_621 VPWR VGND sg13g2_decap_4
XFILLER_20_665 VPWR VGND sg13g2_decap_8
XFILLER_3_319 VPWR VGND sg13g2_decap_8
Xfanout122 net128 net122 VPWR VGND sg13g2_buf_1
Xfanout111 net114 net111 VPWR VGND sg13g2_buf_1
Xfanout100 net103 net100 VPWR VGND sg13g2_buf_1
Xfanout155 net156 net155 VPWR VGND sg13g2_buf_1
Xfanout144 net145 net144 VPWR VGND sg13g2_buf_1
Xfanout133 net137 net133 VPWR VGND sg13g2_buf_1
Xfanout199 net200 net199 VPWR VGND sg13g2_buf_1
Xfanout188 net190 net188 VPWR VGND sg13g2_buf_1
Xfanout177 net178 net177 VPWR VGND sg13g2_buf_1
Xfanout166 net167 net166 VPWR VGND sg13g2_buf_1
XFILLER_47_35 VPWR VGND sg13g2_decap_8
XFILLER_28_721 VPWR VGND sg13g2_fill_1
XFILLER_27_231 VPWR VGND sg13g2_decap_8
XFILLER_42_245 VPWR VGND sg13g2_decap_8
XFILLER_30_429 VPWR VGND sg13g2_decap_4
XFILLER_11_610 VPWR VGND sg13g2_fill_1
XFILLER_8_18 VPWR VGND sg13g2_decap_8
XFILLER_23_481 VPWR VGND sg13g2_decap_4
XFILLER_11_643 VPWR VGND sg13g2_decap_4
XFILLER_7_625 VPWR VGND sg13g2_fill_1
XFILLER_10_186 VPWR VGND sg13g2_decap_8
XFILLER_6_102 VPWR VGND sg13g2_decap_8
XFILLER_12_60 VPWR VGND sg13g2_decap_8
XFILLER_6_179 VPWR VGND sg13g2_decap_8
XFILLER_18_242 VPWR VGND sg13g2_decap_8
XFILLER_33_256 VPWR VGND sg13g2_decap_8
X_1962_ net218 VPWR _0829_ VGND state\[105\] net177 sg13g2_o21ai_1
X_1893_ VPWR VGND _0777_ net97 _0776_ _0241_ _0343_ net49 sg13g2_a221oi_1
X_2548__272 VPWR VGND net271 sg13g2_tiehi
X_2514_ net395 VGND VPWR _0460_ state\[76\] clknet_leaf_9_clk sg13g2_dfrbpq_1
XFILLER_45_0 VPWR VGND sg13g2_decap_8
X_2445_ net461 VGND VPWR _0391_ state\[7\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_2376_ net356 VGND VPWR _0322_ daisychain\[66\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_1327_ VPWR _0110_ state\[84\] VGND sg13g2_inv_1
XFILLER_17_49 VPWR VGND sg13g2_decap_8
XFILLER_24_256 VPWR VGND sg13g2_decap_8
XFILLER_21_930 VPWR VGND sg13g2_fill_2
XFILLER_3_116 VPWR VGND sg13g2_decap_8
XFILLER_0_856 VPWR VGND sg13g2_decap_8
XFILLER_47_315 VPWR VGND sg13g2_decap_8
XFILLER_15_256 VPWR VGND sg13g2_decap_8
XFILLER_11_473 VPWR VGND sg13g2_decap_8
XFILLER_23_81 VPWR VGND sg13g2_decap_8
XFILLER_7_444 VPWR VGND sg13g2_decap_8
X_2230_ _0986_ net141 state\[88\] VPWR VGND sg13g2_nand2_1
XFILLER_2_193 VPWR VGND sg13g2_decap_8
X_2161_ VGND VPWR _0674_ _0951_ _0437_ net101 sg13g2_a21oi_1
XFILLER_38_315 VPWR VGND sg13g2_decap_8
X_2092_ _0917_ net124 state\[19\] VPWR VGND sg13g2_nand2_1
XFILLER_0_1016 VPWR VGND sg13g2_decap_8
XFILLER_0_1027 VPWR VGND sg13g2_fill_2
XFILLER_0_63 VPWR VGND sg13g2_decap_8
XFILLER_46_392 VPWR VGND sg13g2_decap_8
XFILLER_34_532 VPWR VGND sg13g2_fill_1
XFILLER_34_565 VPWR VGND sg13g2_fill_2
XFILLER_34_598 VPWR VGND sg13g2_fill_2
X_1945_ VPWR VGND _0816_ net96 _0815_ _0129_ _0356_ net47 sg13g2_a221oi_1
X_1876_ VGND VPWR net140 daisychain\[82\] _0765_ net45 sg13g2_a21oi_1
XdigitalenL.g\[0\].u.inv2 VPWR digitalenL.g\[0\].u.OUTP digitalenL.g\[0\].u.OUTN VGND
+ sg13g2_inv_1
XFILLER_1_609 VPWR VGND sg13g2_decap_8
XFILLER_0_119 VPWR VGND sg13g2_decap_8
X_2428_ net252 VGND VPWR _0374_ daisychain\[118\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2359_ net390 VGND VPWR _0305_ daisychain\[49\] clknet_leaf_12_clk sg13g2_dfrbpq_1
XFILLER_29_326 VPWR VGND sg13g2_decap_8
XFILLER_44_329 VPWR VGND sg13g2_decap_8
XFILLER_44_14 VPWR VGND sg13g2_decap_8
XFILLER_25_521 VPWR VGND sg13g2_decap_8
XFILLER_20_270 VPWR VGND sg13g2_decap_8
XFILLER_5_926 VPWR VGND sg13g2_fill_1
XFILLER_4_403 VPWR VGND sg13g2_decap_8
XFILLER_47_112 VPWR VGND sg13g2_decap_8
XFILLER_47_189 VPWR VGND sg13g2_decap_8
XFILLER_35_329 VPWR VGND sg13g2_decap_8
XFILLER_44_841 VPWR VGND sg13g2_fill_2
XFILLER_18_81 VPWR VGND sg13g2_decap_8
XFILLER_44_874 VPWR VGND sg13g2_fill_1
XFILLER_31_502 VPWR VGND sg13g2_fill_2
XFILLER_11_270 VPWR VGND sg13g2_decap_8
X_1730_ net224 VPWR _0655_ VGND state\[47\] net194 sg13g2_o21ai_1
X_1661_ VPWR VGND _0603_ net100 _0602_ _0177_ _0285_ net55 sg13g2_a221oi_1
XFILLER_7_252 VPWR VGND sg13g2_decap_8
X_1592_ VGND VPWR net123 daisychain\[11\] _0552_ net30 sg13g2_a21oi_1
XFILLER_4_981 VPWR VGND sg13g2_fill_1
XFILLER_3_480 VPWR VGND sg13g2_decap_8
X_2213_ VGND VPWR _0752_ _0977_ _0463_ net109 sg13g2_a21oi_1
XFILLER_38_112 VPWR VGND sg13g2_decap_8
X_2144_ _0943_ net125 state\[45\] VPWR VGND sg13g2_nand2_1
X_2075_ VGND VPWR _0545_ _0908_ _0394_ net70 sg13g2_a21oi_1
XFILLER_38_189 VPWR VGND sg13g2_decap_8
XFILLER_34_340 VPWR VGND sg13g2_decap_8
XFILLER_14_39 VPWR VGND sg13g2_decap_8
X_1928_ VGND VPWR net143 daisychain\[95\] _0804_ net48 sg13g2_a21oi_1
X_1859_ net204 _0232_ _0751_ _0752_ VPWR VGND sg13g2_a21o_1
XFILLER_2_929 VPWR VGND sg13g2_decap_8
XFILLER_1_406 VPWR VGND sg13g2_decap_8
XFILLER_39_14 VPWR VGND sg13g2_decap_8
XFILLER_29_123 VPWR VGND sg13g2_decap_8
XFILLER_44_126 VPWR VGND sg13g2_decap_8
XFILLER_38_690 VPWR VGND sg13g2_decap_4
XFILLER_17_329 VPWR VGND sg13g2_decap_8
X_2351__407 VPWR VGND net406 sg13g2_tiehi
XFILLER_25_340 VPWR VGND sg13g2_decap_8
XFILLER_40_343 VPWR VGND sg13g2_decap_8
XFILLER_13_568 VPWR VGND sg13g2_decap_4
XFILLER_40_387 VPWR VGND sg13g2_fill_2
XFILLER_5_712 VPWR VGND sg13g2_decap_8
XFILLER_4_200 VPWR VGND sg13g2_decap_8
XFILLER_5_745 VPWR VGND sg13g2_decap_4
XFILLER_5_778 VPWR VGND sg13g2_fill_1
XFILLER_20_60 VPWR VGND sg13g2_decap_8
XFILLER_4_277 VPWR VGND sg13g2_decap_8
XFILLER_0_483 VPWR VGND sg13g2_decap_8
XFILLER_48_443 VPWR VGND sg13g2_decap_8
XFILLER_36_616 VPWR VGND sg13g2_fill_2
XFILLER_36_649 VPWR VGND sg13g2_decap_4
XFILLER_35_126 VPWR VGND sg13g2_decap_8
XFILLER_16_340 VPWR VGND sg13g2_decap_8
X_2831_ state\[121\] net9 VPWR VGND sg13g2_buf_1
XFILLER_31_354 VPWR VGND sg13g2_decap_8
X_1713_ VPWR VGND _0642_ net78 _0641_ _0192_ _0298_ net32 sg13g2_a221oi_1
XFILLER_8_583 VPWR VGND sg13g2_decap_4
X_1644_ VGND VPWR net140 daisychain\[24\] _0591_ net45 sg13g2_a21oi_1
X_1575_ net165 _0244_ _0538_ _0539_ VPWR VGND sg13g2_a21o_1
XFILLER_6_95 VPWR VGND sg13g2_decap_8
XFILLER_39_487 VPWR VGND sg13g2_fill_2
X_2127_ VGND VPWR _0623_ _0934_ _0420_ net73 sg13g2_a21oi_1
XFILLER_26_137 VPWR VGND sg13g2_decap_8
X_2058_ _0900_ net131 state\[2\] VPWR VGND sg13g2_nand2_1
XFILLER_23_855 VPWR VGND sg13g2_decap_8
XFILLER_10_505 VPWR VGND sg13g2_fill_2
XFILLER_22_354 VPWR VGND sg13g2_decap_8
XFILLER_22_398 VPWR VGND sg13g2_fill_1
XFILLER_2_715 VPWR VGND sg13g2_decap_8
XFILLER_1_203 VPWR VGND sg13g2_decap_8
XFILLER_49_207 VPWR VGND sg13g2_decap_8
X_2494__266 VPWR VGND net265 sg13g2_tiehi
XFILLER_18_616 VPWR VGND sg13g2_decap_4
XFILLER_45_413 VPWR VGND sg13g2_decap_8
XFILLER_17_126 VPWR VGND sg13g2_decap_8
XFILLER_41_630 VPWR VGND sg13g2_fill_1
XFILLER_13_354 VPWR VGND sg13g2_decap_8
XFILLER_41_663 VPWR VGND sg13g2_fill_1
XFILLER_40_140 VPWR VGND sg13g2_decap_8
XFILLER_15_60 VPWR VGND sg13g2_decap_8
XFILLER_9_347 VPWR VGND sg13g2_decap_8
XFILLER_5_531 VPWR VGND sg13g2_decap_8
XFILLER_31_81 VPWR VGND sg13g2_decap_8
X_1360_ VPWR _0074_ state\[51\] VGND sg13g2_inv_1
XFILLER_0_280 VPWR VGND sg13g2_decap_8
X_1291_ VPWR _0023_ state\[120\] VGND sg13g2_inv_1
XFILLER_48_273 VPWR VGND sg13g2_decap_8
XFILLER_17_660 VPWR VGND sg13g2_fill_2
XFILLER_31_151 VPWR VGND sg13g2_decap_8
XFILLER_11_18 VPWR VGND sg13g2_decap_8
X_1627_ net183 _0169_ _0577_ _0578_ VPWR VGND sg13g2_a21o_1
XFILLER_28_1001 VPWR VGND sg13g2_fill_1
X_1558_ net216 VPWR _0526_ VGND state\[4\] net177 sg13g2_o21ai_1
X_1489_ VPWR _0201_ daisychain\[50\] VGND sg13g2_inv_1
XFILLER_27_402 VPWR VGND sg13g2_decap_4
XFILLER_39_273 VPWR VGND sg13g2_decap_8
XFILLER_27_479 VPWR VGND sg13g2_decap_8
XFILLER_35_490 VPWR VGND sg13g2_fill_1
XFILLER_22_151 VPWR VGND sg13g2_decap_8
XFILLER_10_368 VPWR VGND sg13g2_decap_8
XFILLER_2_523 VPWR VGND sg13g2_decap_8
XFILLER_46_733 VPWR VGND sg13g2_fill_1
XFILLER_45_210 VPWR VGND sg13g2_decap_8
XFILLER_18_468 VPWR VGND sg13g2_decap_8
XFILLER_45_287 VPWR VGND sg13g2_decap_8
XFILLER_33_427 VPWR VGND sg13g2_fill_2
XFILLER_18_479 VPWR VGND sg13g2_fill_2
XFILLER_33_449 VPWR VGND sg13g2_fill_1
XFILLER_26_81 VPWR VGND sg13g2_decap_8
XFILLER_14_630 VPWR VGND sg13g2_fill_2
XFILLER_13_151 VPWR VGND sg13g2_decap_8
XFILLER_14_674 VPWR VGND sg13g2_decap_8
XFILLER_14_652 VPWR VGND sg13g2_decap_8
XFILLER_41_471 VPWR VGND sg13g2_fill_2
XFILLER_9_144 VPWR VGND sg13g2_decap_8
XFILLER_42_91 VPWR VGND sg13g2_decap_8
X_2530_ net267 VGND VPWR _0476_ state\[92\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_2461_ net397 VGND VPWR _0407_ state\[23\] clknet_leaf_1_clk sg13g2_dfrbpq_1
XFILLER_5_361 VPWR VGND sg13g2_decap_8
X_1412_ VPWR _0158_ daisychain\[127\] VGND sg13g2_inv_1
X_2392_ net324 VGND VPWR _0338_ daisychain\[82\] clknet_leaf_8_clk sg13g2_dfrbpq_1
X_1343_ VPWR _0092_ state\[68\] VGND sg13g2_inv_1
XFILLER_3_74 VPWR VGND sg13g2_decap_8
XFILLER_36_210 VPWR VGND sg13g2_decap_8
XFILLER_36_287 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_16_clk clknet_2_0__leaf_clk clknet_leaf_16_clk VPWR VGND sg13g2_buf_8
XFILLER_32_460 VPWR VGND sg13g2_decap_8
XFILLER_20_600 VPWR VGND sg13g2_decap_4
XFILLER_22_39 VPWR VGND sg13g2_decap_8
XFILLER_20_688 VPWR VGND sg13g2_decap_8
Xfanout112 net114 net112 VPWR VGND sg13g2_buf_1
Xfanout101 net103 net101 VPWR VGND sg13g2_buf_1
Xfanout156 net157 net156 VPWR VGND sg13g2_buf_1
Xfanout145 net146 net145 VPWR VGND sg13g2_buf_1
Xfanout134 net137 net134 VPWR VGND sg13g2_buf_1
Xfanout123 net127 net123 VPWR VGND sg13g2_buf_1
Xfanout189 net190 net189 VPWR VGND sg13g2_buf_1
Xfanout178 net182 net178 VPWR VGND sg13g2_buf_1
Xfanout167 net192 net167 VPWR VGND sg13g2_buf_1
XFILLER_47_14 VPWR VGND sg13g2_decap_8
XFILLER_27_210 VPWR VGND sg13g2_decap_8
XFILLER_28_777 VPWR VGND sg13g2_fill_2
XFILLER_28_755 VPWR VGND sg13g2_fill_2
XFILLER_42_224 VPWR VGND sg13g2_decap_8
XFILLER_27_287 VPWR VGND sg13g2_decap_8
XFILLER_15_449 VPWR VGND sg13g2_fill_2
XFILLER_10_165 VPWR VGND sg13g2_decap_8
XFILLER_6_158 VPWR VGND sg13g2_decap_8
XFILLER_2_375 VPWR VGND sg13g2_decap_8
XFILLER_2_397 VPWR VGND sg13g2_decap_8
XFILLER_38_519 VPWR VGND sg13g2_fill_1
XFILLER_19_722 VPWR VGND sg13g2_fill_1
XFILLER_19_711 VPWR VGND sg13g2_decap_8
XFILLER_18_221 VPWR VGND sg13g2_decap_8
XFILLER_37_91 VPWR VGND sg13g2_decap_8
XFILLER_33_235 VPWR VGND sg13g2_decap_8
XFILLER_18_298 VPWR VGND sg13g2_decap_8
X_1961_ VPWR VGND _0828_ net87 _0827_ _0133_ _0360_ net40 sg13g2_a221oi_1
X_1892_ VGND VPWR net144 daisychain\[86\] _0777_ net49 sg13g2_a21oi_1
X_2513_ net403 VGND VPWR _0459_ state\[75\] clknet_leaf_12_clk sg13g2_dfrbpq_1
X_2444_ net465 VGND VPWR _0390_ state\[6\] clknet_leaf_2_clk sg13g2_dfrbpq_1
Xclkbuf_leaf_5_clk clknet_2_1__leaf_clk clknet_leaf_5_clk VPWR VGND sg13g2_buf_8
X_2375_ net358 VGND VPWR _0321_ daisychain\[65\] clknet_leaf_10_clk sg13g2_dfrbpq_1
X_2405__299 VPWR VGND net298 sg13g2_tiehi
XFILLER_38_0 VPWR VGND sg13g2_decap_8
X_1326_ VPWR _0111_ state\[85\] VGND sg13g2_inv_1
XFILLER_29_519 VPWR VGND sg13g2_fill_2
XFILLER_17_28 VPWR VGND sg13g2_decap_8
XFILLER_24_235 VPWR VGND sg13g2_decap_8
XFILLER_20_430 VPWR VGND sg13g2_fill_1
XFILLER_0_835 VPWR VGND sg13g2_fill_1
XFILLER_16_703 VPWR VGND sg13g2_decap_8
XFILLER_15_235 VPWR VGND sg13g2_decap_8
XFILLER_43_577 VPWR VGND sg13g2_decap_8
XFILLER_30_249 VPWR VGND sg13g2_decap_8
XFILLER_11_452 VPWR VGND sg13g2_decap_8
XFILLER_7_423 VPWR VGND sg13g2_decap_8
XFILLER_23_60 VPWR VGND sg13g2_decap_8
XFILLER_3_695 VPWR VGND sg13g2_fill_2
XFILLER_2_172 VPWR VGND sg13g2_decap_8
X_2160_ _0951_ net148 state\[53\] VPWR VGND sg13g2_nand2_1
X_2091_ VGND VPWR _0569_ _0916_ _0402_ net76 sg13g2_a21oi_1
XFILLER_0_42 VPWR VGND sg13g2_decap_8
XFILLER_46_371 VPWR VGND sg13g2_decap_8
XFILLER_34_522 VPWR VGND sg13g2_fill_1
XFILLER_22_728 VPWR VGND sg13g2_decap_4
X_1944_ VGND VPWR net142 daisychain\[99\] _0816_ net47 sg13g2_a21oi_1
XFILLER_21_249 VPWR VGND sg13g2_decap_8
XFILLER_9_95 VPWR VGND sg13g2_decap_8
X_1875_ net186 _0237_ _0763_ _0764_ VPWR VGND sg13g2_a21o_1
X_2427_ net254 VGND VPWR _0373_ daisychain\[117\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2358_ net392 VGND VPWR _0304_ daisychain\[48\] clknet_leaf_12_clk sg13g2_dfrbpq_1
XFILLER_29_305 VPWR VGND sg13g2_decap_8
X_2289_ VGND VPWR _0866_ _1015_ _0501_ net89 sg13g2_a21oi_1
X_1309_ VPWR _0003_ state\[102\] VGND sg13g2_inv_1
XFILLER_44_308 VPWR VGND sg13g2_decap_8
XFILLER_37_393 VPWR VGND sg13g2_decap_4
XFILLER_12_249 VPWR VGND sg13g2_decap_8
XFILLER_40_558 VPWR VGND sg13g2_fill_1
XFILLER_47_168 VPWR VGND sg13g2_decap_8
XFILLER_35_308 VPWR VGND sg13g2_decap_8
XFILLER_18_60 VPWR VGND sg13g2_decap_8
X_2358__393 VPWR VGND net392 sg13g2_tiehi
X_2512__412 VPWR VGND net411 sg13g2_tiehi
X_2551__472 VPWR VGND net471 sg13g2_tiehi
XFILLER_44_886 VPWR VGND sg13g2_decap_4
XFILLER_31_525 VPWR VGND sg13g2_decap_8
XFILLER_34_81 VPWR VGND sg13g2_decap_8
X_2469__366 VPWR VGND net365 sg13g2_tiehi
XFILLER_7_231 VPWR VGND sg13g2_decap_8
X_1660_ VGND VPWR net147 daisychain\[28\] _0603_ net55 sg13g2_a21oi_1
X_1591_ net168 _0159_ _0550_ _0551_ VPWR VGND sg13g2_a21o_1
X_2212_ _0977_ net156 state\[79\] VPWR VGND sg13g2_nand2_1
XFILLER_39_603 VPWR VGND sg13g2_decap_8
X_2143_ VGND VPWR _0647_ _0942_ _0428_ net77 sg13g2_a21oi_1
XFILLER_39_647 VPWR VGND sg13g2_decap_4
XFILLER_38_168 VPWR VGND sg13g2_decap_8
XFILLER_26_319 VPWR VGND sg13g2_decap_8
X_2074_ _0908_ net117 state\[10\] VPWR VGND sg13g2_nand2_1
XFILLER_19_382 VPWR VGND sg13g2_fill_2
XFILLER_22_525 VPWR VGND sg13g2_decap_8
XFILLER_22_503 VPWR VGND sg13g2_decap_8
XFILLER_14_18 VPWR VGND sg13g2_decap_8
XFILLER_10_709 VPWR VGND sg13g2_fill_1
X_1927_ net188 _0251_ _0802_ _0803_ VPWR VGND sg13g2_a21o_1
X_1858_ net230 VPWR _0751_ VGND state\[79\] net204 sg13g2_o21ai_1
X_2524__316 VPWR VGND net315 sg13g2_tiehi
XFILLER_30_39 VPWR VGND sg13g2_decap_8
X_1789_ VPWR VGND _0699_ net106 _0698_ _0213_ _0317_ net57 sg13g2_a221oi_1
XFILLER_29_102 VPWR VGND sg13g2_decap_8
XFILLER_45_617 VPWR VGND sg13g2_decap_8
XFILLER_29_179 VPWR VGND sg13g2_decap_8
XFILLER_17_308 VPWR VGND sg13g2_decap_8
XFILLER_44_105 VPWR VGND sg13g2_decap_8
XFILLER_26_875 VPWR VGND sg13g2_fill_2
XFILLER_40_322 VPWR VGND sg13g2_decap_8
XFILLER_4_256 VPWR VGND sg13g2_decap_8
XFILLER_0_462 VPWR VGND sg13g2_decap_8
XFILLER_1_996 VPWR VGND sg13g2_fill_1
XFILLER_48_422 VPWR VGND sg13g2_decap_8
XFILLER_49_978 VPWR VGND sg13g2_fill_2
XFILLER_29_81 VPWR VGND sg13g2_decap_8
XFILLER_35_105 VPWR VGND sg13g2_decap_8
XFILLER_45_91 VPWR VGND sg13g2_decap_8
XFILLER_44_683 VPWR VGND sg13g2_fill_1
XFILLER_44_672 VPWR VGND sg13g2_decap_4
X_2830_ state\[120\] net8 VPWR VGND sg13g2_buf_1
XFILLER_43_182 VPWR VGND sg13g2_decap_8
XFILLER_31_333 VPWR VGND sg13g2_decap_8
XFILLER_16_396 VPWR VGND sg13g2_fill_2
XFILLER_31_399 VPWR VGND sg13g2_decap_4
X_1712_ VGND VPWR net126 daisychain\[41\] _0642_ net32 sg13g2_a21oi_1
XANTENNA_1 VPWR VGND _0162_ sg13g2_antennanp
X_1643_ net185 _0173_ _0589_ _0590_ VPWR VGND sg13g2_a21o_1
XFILLER_6_74 VPWR VGND sg13g2_decap_8
X_1574_ net209 VPWR _0538_ VGND state\[8\] net165 sg13g2_o21ai_1
X_2126_ _0934_ net120 state\[36\] VPWR VGND sg13g2_nand2_1
XFILLER_26_116 VPWR VGND sg13g2_decap_8
X_2057_ VGND VPWR _0518_ _0899_ _0385_ net82 sg13g2_a21oi_1
XFILLER_41_119 VPWR VGND sg13g2_decap_8
XFILLER_25_39 VPWR VGND sg13g2_decap_8
XFILLER_34_193 VPWR VGND sg13g2_decap_8
XFILLER_22_333 VPWR VGND sg13g2_decap_8
XFILLER_41_49 VPWR VGND sg13g2_decap_8
XFILLER_1_259 VPWR VGND sg13g2_decap_8
XFILLER_17_105 VPWR VGND sg13g2_decap_8
XFILLER_13_333 VPWR VGND sg13g2_decap_8
XFILLER_25_193 VPWR VGND sg13g2_decap_8
XFILLER_41_686 VPWR VGND sg13g2_fill_2
XFILLER_9_326 VPWR VGND sg13g2_decap_8
XFILLER_40_196 VPWR VGND sg13g2_decap_8
XFILLER_5_510 VPWR VGND sg13g2_decap_8
XFILLER_31_60 VPWR VGND sg13g2_decap_8
X_1290_ VPWR _0024_ state\[121\] VGND sg13g2_inv_1
XFILLER_49_786 VPWR VGND sg13g2_fill_2
XFILLER_49_753 VPWR VGND sg13g2_fill_2
XFILLER_48_252 VPWR VGND sg13g2_decap_8
XFILLER_16_193 VPWR VGND sg13g2_decap_8
XFILLER_31_130 VPWR VGND sg13g2_decap_8
X_1626_ net218 VPWR _0577_ VGND state\[21\] net183 sg13g2_o21ai_1
X_1557_ VPWR VGND _0525_ net84 _0524_ _0189_ _0259_ net38 sg13g2_a221oi_1
X_1488_ VPWR _0202_ daisychain\[51\] VGND sg13g2_inv_1
XFILLER_39_252 VPWR VGND sg13g2_decap_8
X_2109_ VGND VPWR _0596_ _0925_ _0411_ net74 sg13g2_a21oi_1
XFILLER_36_49 VPWR VGND sg13g2_decap_8
XFILLER_15_609 VPWR VGND sg13g2_fill_2
X_2415__279 VPWR VGND net278 sg13g2_tiehi
XFILLER_42_439 VPWR VGND sg13g2_decap_4
XFILLER_23_664 VPWR VGND sg13g2_decap_8
XFILLER_22_130 VPWR VGND sg13g2_decap_8
XFILLER_10_347 VPWR VGND sg13g2_decap_8
XFILLER_2_502 VPWR VGND sg13g2_decap_8
XFILLER_2_579 VPWR VGND sg13g2_decap_8
XFILLER_46_778 VPWR VGND sg13g2_decap_8
XFILLER_45_266 VPWR VGND sg13g2_decap_8
XFILLER_27_981 VPWR VGND sg13g2_decap_4
XFILLER_26_60 VPWR VGND sg13g2_decap_8
XFILLER_13_130 VPWR VGND sg13g2_decap_8
XFILLER_14_664 VPWR VGND sg13g2_fill_1
XFILLER_9_123 VPWR VGND sg13g2_decap_8
XFILLER_41_461 VPWR VGND sg13g2_decap_4
XFILLER_42_70 VPWR VGND sg13g2_decap_8
XFILLER_5_340 VPWR VGND sg13g2_decap_8
X_2460_ net401 VGND VPWR _0406_ state\[22\] clknet_leaf_1_clk sg13g2_dfrbpq_1
X_1411_ VPWR _0000_ state\[0\] VGND sg13g2_inv_1
X_2391_ net326 VGND VPWR _0337_ daisychain\[81\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_1342_ VPWR _0093_ state\[69\] VGND sg13g2_inv_1
XFILLER_3_53 VPWR VGND sg13g2_decap_8
XFILLER_49_561 VPWR VGND sg13g2_fill_2
XFILLER_49_583 VPWR VGND sg13g2_decap_8
XFILLER_36_266 VPWR VGND sg13g2_decap_8
XFILLER_25_918 VPWR VGND sg13g2_fill_2
XFILLER_24_439 VPWR VGND sg13g2_fill_2
XFILLER_17_480 VPWR VGND sg13g2_decap_8
XFILLER_22_18 VPWR VGND sg13g2_decap_8
X_1609_ VPWR VGND _0564_ net76 _0563_ _0163_ _0272_ net29 sg13g2_a221oi_1
Xfanout113 net114 net113 VPWR VGND sg13g2_buf_1
Xfanout102 net103 net102 VPWR VGND sg13g2_buf_1
Xfanout146 net163 net146 VPWR VGND sg13g2_buf_1
Xfanout135 net137 net135 VPWR VGND sg13g2_buf_1
Xfanout124 net127 net124 VPWR VGND sg13g2_buf_1
Xfanout179 net182 net179 VPWR VGND sg13g2_buf_1
Xfanout168 net171 net168 VPWR VGND sg13g2_buf_1
Xfanout157 net163 net157 VPWR VGND sg13g2_buf_1
XFILLER_42_203 VPWR VGND sg13g2_decap_8
XFILLER_27_266 VPWR VGND sg13g2_decap_8
XFILLER_15_428 VPWR VGND sg13g2_decap_8
X_2317__475 VPWR VGND net474 sg13g2_tiehi
XFILLER_30_409 VPWR VGND sg13g2_fill_2
XFILLER_24_962 VPWR VGND sg13g2_decap_8
XFILLER_10_144 VPWR VGND sg13g2_decap_8
XFILLER_6_137 VPWR VGND sg13g2_decap_8
XFILLER_12_95 VPWR VGND sg13g2_decap_8
X_2543__352 VPWR VGND net351 sg13g2_tiehi
XFILLER_3_888 VPWR VGND sg13g2_fill_2
XFILLER_2_354 VPWR VGND sg13g2_decap_8
XFILLER_18_200 VPWR VGND sg13g2_decap_8
XFILLER_37_70 VPWR VGND sg13g2_decap_8
XFILLER_18_277 VPWR VGND sg13g2_decap_8
XFILLER_33_214 VPWR VGND sg13g2_decap_8
X_1960_ VGND VPWR net134 daisychain\[103\] _0828_ net40 sg13g2_a21oi_1
X_1891_ net189 _0241_ _0775_ _0776_ VPWR VGND sg13g2_a21o_1
XFILLER_41_280 VPWR VGND sg13g2_decap_8
X_2368__373 VPWR VGND net372 sg13g2_tiehi
X_2512_ net411 VGND VPWR _0458_ state\[74\] clknet_leaf_12_clk sg13g2_dfrbpq_1
XFILLER_6_693 VPWR VGND sg13g2_fill_2
X_2443_ net469 VGND VPWR _0389_ state\[5\] clknet_leaf_2_clk sg13g2_dfrbpq_1
X_2374_ net360 VGND VPWR _0320_ daisychain\[64\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_1325_ VPWR _0112_ state\[86\] VGND sg13g2_inv_1
XFILLER_37_542 VPWR VGND sg13g2_decap_8
XFILLER_25_759 VPWR VGND sg13g2_decap_8
XFILLER_24_214 VPWR VGND sg13g2_decap_8
XFILLER_40_718 VPWR VGND sg13g2_fill_2
XFILLER_33_39 VPWR VGND sg13g2_decap_8
XFILLER_32_291 VPWR VGND sg13g2_decap_8
XFILLER_21_943 VPWR VGND sg13g2_fill_1
XFILLER_21_998 VPWR VGND sg13g2_fill_2
X_2462__394 VPWR VGND net393 sg13g2_tiehi
X_2538__432 VPWR VGND net431 sg13g2_tiehi
XFILLER_15_214 VPWR VGND sg13g2_decap_8
XFILLER_43_589 VPWR VGND sg13g2_decap_8
XFILLER_30_228 VPWR VGND sg13g2_decap_8
XFILLER_11_431 VPWR VGND sg13g2_decap_8
XFILLER_23_291 VPWR VGND sg13g2_decap_8
XFILLER_7_479 VPWR VGND sg13g2_decap_8
X_2441__478 VPWR VGND net477 sg13g2_tiehi
XFILLER_2_151 VPWR VGND sg13g2_decap_8
X_2090_ _0916_ net123 state\[18\] VPWR VGND sg13g2_nand2_1
XFILLER_48_91 VPWR VGND sg13g2_decap_8
XFILLER_19_542 VPWR VGND sg13g2_decap_8
XFILLER_0_21 VPWR VGND sg13g2_decap_8
XFILLER_47_862 VPWR VGND sg13g2_fill_2
XFILLER_46_350 VPWR VGND sg13g2_decap_8
XFILLER_19_553 VPWR VGND sg13g2_fill_1
XFILLER_0_98 VPWR VGND sg13g2_decap_8
XFILLER_21_228 VPWR VGND sg13g2_decap_8
X_1943_ net184 _0129_ _0814_ _0815_ VPWR VGND sg13g2_a21o_1
XFILLER_14_291 VPWR VGND sg13g2_decap_8
XFILLER_9_74 VPWR VGND sg13g2_decap_8
X_1874_ net219 VPWR _0763_ VGND state\[83\] net186 sg13g2_o21ai_1
X_2426_ net256 VGND VPWR _0372_ daisychain\[116\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2357_ net394 VGND VPWR _0303_ daisychain\[47\] clknet_leaf_15_clk sg13g2_dfrbpq_1
XFILLER_28_39 VPWR VGND sg13g2_decap_8
X_2288_ _1015_ net136 state\[117\] VPWR VGND sg13g2_nand2_1
X_1308_ VPWR _0004_ state\[103\] VGND sg13g2_inv_1
XFILLER_37_350 VPWR VGND sg13g2_decap_8
XFILLER_44_49 VPWR VGND sg13g2_decap_8
XFILLER_12_228 VPWR VGND sg13g2_decap_8
XFILLER_40_537 VPWR VGND sg13g2_fill_2
XFILLER_21_740 VPWR VGND sg13g2_decap_8
XFILLER_5_906 VPWR VGND sg13g2_fill_1
XFILLER_5_939 VPWR VGND sg13g2_fill_1
XFILLER_4_449 VPWR VGND sg13g2_fill_1
XFILLER_4_438 VPWR VGND sg13g2_decap_8
XFILLER_0_644 VPWR VGND sg13g2_decap_8
X_2497__254 VPWR VGND net253 sg13g2_tiehi
XFILLER_0_677 VPWR VGND sg13g2_decap_8
XFILLER_47_147 VPWR VGND sg13g2_decap_8
XFILLER_28_361 VPWR VGND sg13g2_decap_8
XFILLER_43_364 VPWR VGND sg13g2_decap_8
XFILLER_34_60 VPWR VGND sg13g2_decap_8
XFILLER_31_559 VPWR VGND sg13g2_decap_4
XFILLER_7_210 VPWR VGND sg13g2_decap_8
X_1590_ net211 VPWR _0550_ VGND state\[12\] net168 sg13g2_o21ai_1
XFILLER_7_287 VPWR VGND sg13g2_decap_8
XFILLER_4_972 VPWR VGND sg13g2_fill_2
X_2211_ VGND VPWR _0749_ _0976_ _0462_ net109 sg13g2_a21oi_1
X_2476__338 VPWR VGND net337 sg13g2_tiehi
XFILLER_22_4 VPWR VGND sg13g2_decap_8
X_2142_ _0942_ net125 state\[44\] VPWR VGND sg13g2_nand2_1
X_2073_ VGND VPWR _0542_ _0907_ _0393_ net71 sg13g2_a21oi_1
XFILLER_38_147 VPWR VGND sg13g2_decap_8
XFILLER_19_361 VPWR VGND sg13g2_decap_8
XFILLER_19_394 VPWR VGND sg13g2_fill_2
XFILLER_34_375 VPWR VGND sg13g2_fill_1
XFILLER_22_537 VPWR VGND sg13g2_decap_4
X_1926_ net220 VPWR _0802_ VGND state\[96\] net187 sg13g2_o21ai_1
X_1857_ VPWR VGND _0750_ net112 _0749_ _0231_ _0334_ net66 sg13g2_a221oi_1
XFILLER_30_18 VPWR VGND sg13g2_decap_8
X_1788_ VGND VPWR net153 daisychain\[60\] _0699_ net57 sg13g2_a21oi_1
X_2409_ net290 VGND VPWR _0355_ daisychain\[99\] clknet_leaf_7_clk sg13g2_dfrbpq_1
XFILLER_39_49 VPWR VGND sg13g2_decap_8
XFILLER_29_158 VPWR VGND sg13g2_decap_8
XFILLER_40_301 VPWR VGND sg13g2_decap_8
XFILLER_9_508 VPWR VGND sg13g2_decap_8
XFILLER_40_389 VPWR VGND sg13g2_fill_1
X_2425__259 VPWR VGND net258 sg13g2_tiehi
XFILLER_5_758 VPWR VGND sg13g2_fill_2
XFILLER_4_235 VPWR VGND sg13g2_decap_8
XFILLER_20_95 VPWR VGND sg13g2_decap_8
XFILLER_0_441 VPWR VGND sg13g2_decap_8
XFILLER_49_913 VPWR VGND sg13g2_fill_2
XFILLER_48_401 VPWR VGND sg13g2_decap_8
XFILLER_29_60 VPWR VGND sg13g2_decap_8
XFILLER_36_618 VPWR VGND sg13g2_fill_1
XFILLER_45_70 VPWR VGND sg13g2_decap_8
XFILLER_43_161 VPWR VGND sg13g2_decap_8
XFILLER_16_375 VPWR VGND sg13g2_decap_8
XFILLER_31_312 VPWR VGND sg13g2_decap_8
XFILLER_12_581 VPWR VGND sg13g2_decap_8
X_1711_ net174 _0192_ _0640_ _0641_ VPWR VGND sg13g2_a21o_1
XANTENNA_2 VPWR VGND _0163_ sg13g2_antennanp
X_1642_ net229 VPWR _0589_ VGND state\[25\] net185 sg13g2_o21ai_1
XFILLER_6_53 VPWR VGND sg13g2_decap_8
X_1573_ VPWR VGND _0537_ net84 _0536_ _0233_ _0263_ net38 sg13g2_a221oi_1
X_2125_ VGND VPWR _0620_ _0933_ _0419_ net74 sg13g2_a21oi_1
XFILLER_39_489 VPWR VGND sg13g2_fill_1
X_2056_ _0899_ net129 state\[1\] VPWR VGND sg13g2_nand2_1
XFILLER_35_651 VPWR VGND sg13g2_fill_2
XFILLER_25_18 VPWR VGND sg13g2_decap_8
XFILLER_35_684 VPWR VGND sg13g2_decap_8
XFILLER_34_172 VPWR VGND sg13g2_decap_8
XFILLER_22_312 VPWR VGND sg13g2_decap_8
XFILLER_10_507 VPWR VGND sg13g2_fill_1
XFILLER_41_28 VPWR VGND sg13g2_decap_8
XFILLER_22_389 VPWR VGND sg13g2_decap_8
X_1909_ VPWR VGND _0789_ net108 _0788_ _0246_ _0347_ net61 sg13g2_a221oi_1
XFILLER_1_238 VPWR VGND sg13g2_decap_8
XFILLER_45_426 VPWR VGND sg13g2_decap_8
XFILLER_32_109 VPWR VGND sg13g2_decap_8
XFILLER_13_312 VPWR VGND sg13g2_decap_8
XFILLER_41_621 VPWR VGND sg13g2_decap_8
XFILLER_25_172 VPWR VGND sg13g2_decap_8
XFILLER_9_305 VPWR VGND sg13g2_decap_8
XFILLER_13_389 VPWR VGND sg13g2_decap_8
XFILLER_40_175 VPWR VGND sg13g2_decap_8
XFILLER_15_95 VPWR VGND sg13g2_decap_8
X_2327__455 VPWR VGND net454 sg13g2_tiehi
XFILLER_5_566 VPWR VGND sg13g2_decap_8
XFILLER_48_231 VPWR VGND sg13g2_decap_8
XFILLER_45_960 VPWR VGND sg13g2_fill_2
XFILLER_23_109 VPWR VGND sg13g2_decap_8
XFILLER_45_993 VPWR VGND sg13g2_fill_1
XFILLER_32_621 VPWR VGND sg13g2_fill_2
XFILLER_17_684 VPWR VGND sg13g2_decap_4
XFILLER_16_172 VPWR VGND sg13g2_decap_8
XFILLER_31_186 VPWR VGND sg13g2_decap_8
XFILLER_8_382 VPWR VGND sg13g2_decap_8
X_1625_ VPWR VGND _0576_ net92 _0575_ _0168_ _0276_ net46 sg13g2_a221oi_1
X_1556_ VGND VPWR net131 daisychain\[2\] _0525_ net38 sg13g2_a21oi_1
X_1487_ VPWR _0203_ daisychain\[52\] VGND sg13g2_inv_1
X_2378__353 VPWR VGND net352 sg13g2_tiehi
XFILLER_39_231 VPWR VGND sg13g2_decap_8
XFILLER_28_905 VPWR VGND sg13g2_fill_1
XFILLER_36_28 VPWR VGND sg13g2_decap_8
X_2108_ _0925_ net121 state\[27\] VPWR VGND sg13g2_nand2_1
XFILLER_14_109 VPWR VGND sg13g2_decap_8
X_2039_ net166 _0155_ _0886_ _0887_ VPWR VGND sg13g2_a21o_1
XFILLER_23_654 VPWR VGND sg13g2_decap_4
XFILLER_10_326 VPWR VGND sg13g2_decap_8
XFILLER_22_186 VPWR VGND sg13g2_decap_8
XFILLER_6_319 VPWR VGND sg13g2_decap_8
XFILLER_2_558 VPWR VGND sg13g2_decap_8
XFILLER_45_245 VPWR VGND sg13g2_decap_8
XFILLER_18_448 VPWR VGND sg13g2_fill_1
XFILLER_18_437 VPWR VGND sg13g2_decap_8
XFILLER_26_492 VPWR VGND sg13g2_fill_2
XFILLER_9_102 VPWR VGND sg13g2_decap_8
XFILLER_41_484 VPWR VGND sg13g2_decap_4
XFILLER_41_473 VPWR VGND sg13g2_fill_1
XFILLER_13_186 VPWR VGND sg13g2_decap_8
XFILLER_9_179 VPWR VGND sg13g2_decap_8
X_1410_ VPWR _0039_ state\[1\] VGND sg13g2_inv_1
XFILLER_5_396 VPWR VGND sg13g2_decap_8
X_2390_ net328 VGND VPWR _0336_ daisychain\[80\] clknet_leaf_9_clk sg13g2_dfrbpq_1
X_1341_ VPWR _0095_ state\[70\] VGND sg13g2_inv_1
XFILLER_3_32 VPWR VGND sg13g2_decap_8
XFILLER_36_245 VPWR VGND sg13g2_decap_8
XFILLER_17_492 VPWR VGND sg13g2_decap_8
X_1608_ VGND VPWR net123 daisychain\[15\] _0564_ net29 sg13g2_a21oi_1
Xfanout103 net106 net103 VPWR VGND sg13g2_buf_1
Xfanout147 net150 net147 VPWR VGND sg13g2_buf_1
Xfanout136 net137 net136 VPWR VGND sg13g2_buf_1
Xfanout125 net127 net125 VPWR VGND sg13g2_buf_1
Xfanout114 net115 net114 VPWR VGND sg13g2_buf_1
XdigitalenL.g\[3\].u.inv1 VPWR digitalenL.g\[3\].u.OUTN net6 VGND sg13g2_inv_1
X_1539_ VPWR _0128_ daisychain\[0\] VGND sg13g2_inv_1
Xfanout169 net171 net169 VPWR VGND sg13g2_buf_1
Xfanout158 net162 net158 VPWR VGND sg13g2_buf_1
XFILLER_47_49 VPWR VGND sg13g2_decap_8
XFILLER_28_757 VPWR VGND sg13g2_fill_1
XFILLER_43_716 VPWR VGND sg13g2_decap_8
XFILLER_27_245 VPWR VGND sg13g2_decap_8
XFILLER_42_259 VPWR VGND sg13g2_decap_8
XFILLER_24_996 VPWR VGND sg13g2_decap_8
XFILLER_10_123 VPWR VGND sg13g2_decap_8
XFILLER_6_116 VPWR VGND sg13g2_decap_8
XFILLER_12_74 VPWR VGND sg13g2_decap_8
XFILLER_3_801 VPWR VGND sg13g2_fill_1
XFILLER_2_333 VPWR VGND sg13g2_decap_8
XFILLER_18_256 VPWR VGND sg13g2_decap_8
X_1890_ net221 VPWR _0775_ VGND state\[87\] net189 sg13g2_o21ai_1
X_2511_ net419 VGND VPWR _0457_ state\[73\] clknet_leaf_12_clk sg13g2_dfrbpq_1
XFILLER_6_650 VPWR VGND sg13g2_fill_2
X_2442_ net473 VGND VPWR _0388_ state\[4\] clknet_leaf_2_clk sg13g2_dfrbpq_1
XFILLER_5_193 VPWR VGND sg13g2_decap_8
X_2373_ net362 VGND VPWR _0319_ daisychain\[63\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_1324_ VPWR _0113_ state\[87\] VGND sg13g2_inv_1
XFILLER_25_1028 VPWR VGND sg13g2_fill_1
XFILLER_25_1017 VPWR VGND sg13g2_decap_8
X_2490__282 VPWR VGND net281 sg13g2_tiehi
XFILLER_33_18 VPWR VGND sg13g2_decap_8
XFILLER_21_922 VPWR VGND sg13g2_fill_1
XFILLER_32_270 VPWR VGND sg13g2_decap_8
XFILLER_20_443 VPWR VGND sg13g2_decap_8
XFILLER_47_329 VPWR VGND sg13g2_decap_8
XFILLER_30_207 VPWR VGND sg13g2_decap_8
XFILLER_11_410 VPWR VGND sg13g2_decap_8
XFILLER_23_270 VPWR VGND sg13g2_decap_8
XFILLER_7_403 VPWR VGND sg13g2_fill_2
XFILLER_11_487 VPWR VGND sg13g2_decap_8
XFILLER_7_458 VPWR VGND sg13g2_decap_8
XFILLER_23_95 VPWR VGND sg13g2_decap_8
XFILLER_2_130 VPWR VGND sg13g2_decap_8
XFILLER_3_697 VPWR VGND sg13g2_fill_1
XFILLER_48_70 VPWR VGND sg13g2_decap_8
XFILLER_38_329 VPWR VGND sg13g2_decap_8
XFILLER_17_7 VPWR VGND sg13g2_decap_8
XFILLER_0_77 VPWR VGND sg13g2_decap_8
X_2435__239 VPWR VGND net238 sg13g2_tiehi
XFILLER_22_708 VPWR VGND sg13g2_decap_8
XFILLER_21_207 VPWR VGND sg13g2_decap_8
X_1942_ net218 VPWR _0814_ VGND state\[100\] net184 sg13g2_o21ai_1
XFILLER_9_53 VPWR VGND sg13g2_decap_8
XFILLER_14_270 VPWR VGND sg13g2_decap_8
X_1873_ VPWR VGND _0762_ net107 _0761_ _0236_ _0338_ net59 sg13g2_a221oi_1
XFILLER_43_0 VPWR VGND sg13g2_decap_8
X_2425_ net258 VGND VPWR _0371_ daisychain\[115\] clknet_leaf_4_clk sg13g2_dfrbpq_1
X_2356_ net396 VGND VPWR _0302_ daisychain\[46\] clknet_leaf_15_clk sg13g2_dfrbpq_1
XFILLER_28_18 VPWR VGND sg13g2_decap_8
X_2287_ VGND VPWR _0863_ _1014_ _0500_ net89 sg13g2_a21oi_1
X_1307_ VPWR _0005_ state\[104\] VGND sg13g2_inv_1
XFILLER_44_28 VPWR VGND sg13g2_decap_8
XFILLER_12_207 VPWR VGND sg13g2_decap_8
XFILLER_40_549 VPWR VGND sg13g2_decap_8
XFILLER_20_284 VPWR VGND sg13g2_decap_8
XFILLER_5_918 VPWR VGND sg13g2_fill_1
XFILLER_4_417 VPWR VGND sg13g2_decap_8
XFILLER_0_623 VPWR VGND sg13g2_decap_8
XFILLER_47_126 VPWR VGND sg13g2_decap_8
XFILLER_28_340 VPWR VGND sg13g2_decap_8
XFILLER_18_95 VPWR VGND sg13g2_decap_8
XFILLER_43_343 VPWR VGND sg13g2_decap_8
XFILLER_43_398 VPWR VGND sg13g2_decap_8
XFILLER_11_284 VPWR VGND sg13g2_decap_8
XFILLER_7_266 VPWR VGND sg13g2_decap_8
X_2210_ _0976_ net156 state\[78\] VPWR VGND sg13g2_nand2_1
XFILLER_3_494 VPWR VGND sg13g2_decap_8
X_2141_ VGND VPWR _0644_ _0941_ _0427_ net76 sg13g2_a21oi_1
XFILLER_38_126 VPWR VGND sg13g2_decap_8
XFILLER_15_4 VPWR VGND sg13g2_decap_8
X_2072_ _0907_ net117 state\[9\] VPWR VGND sg13g2_nand2_1
XFILLER_19_340 VPWR VGND sg13g2_decap_8
X_2337__435 VPWR VGND net434 sg13g2_tiehi
XFILLER_34_354 VPWR VGND sg13g2_decap_8
X_1925_ VPWR VGND _0801_ net95 _0800_ _0250_ _0351_ net48 sg13g2_a221oi_1
X_1856_ VGND VPWR net160 daisychain\[77\] _0750_ net66 sg13g2_a21oi_1
XFILLER_30_593 VPWR VGND sg13g2_decap_8
X_1787_ net197 _0213_ _0697_ _0698_ VPWR VGND sg13g2_a21o_1
XFILLER_39_28 VPWR VGND sg13g2_decap_8
X_2408_ net292 VGND VPWR _0354_ daisychain\[98\] clknet_leaf_7_clk sg13g2_dfrbpq_1
X_2339_ net430 VGND VPWR _0285_ daisychain\[29\] clknet_leaf_15_clk sg13g2_dfrbpq_1
XFILLER_29_137 VPWR VGND sg13g2_decap_8
XFILLER_25_354 VPWR VGND sg13g2_decap_8
X_2388__333 VPWR VGND net332 sg13g2_tiehi
XFILLER_40_357 VPWR VGND sg13g2_decap_8
XFILLER_5_726 VPWR VGND sg13g2_fill_1
XFILLER_4_214 VPWR VGND sg13g2_decap_8
XFILLER_20_74 VPWR VGND sg13g2_decap_8
XFILLER_0_420 VPWR VGND sg13g2_decap_8
XFILLER_49_925 VPWR VGND sg13g2_fill_1
XFILLER_0_497 VPWR VGND sg13g2_decap_8
XFILLER_48_457 VPWR VGND sg13g2_decap_8
XFILLER_29_682 VPWR VGND sg13g2_decap_8
X_2516__380 VPWR VGND net379 sg13g2_tiehi
XFILLER_43_140 VPWR VGND sg13g2_decap_8
XFILLER_16_354 VPWR VGND sg13g2_decap_8
XFILLER_16_398 VPWR VGND sg13g2_fill_1
XFILLER_31_368 VPWR VGND sg13g2_decap_4
X_1710_ net213 VPWR _0640_ VGND state\[42\] net174 sg13g2_o21ai_1
XANTENNA_3 VPWR VGND _0163_ sg13g2_antennanp
X_1641_ VPWR VGND _0588_ net93 _0587_ _0172_ _0280_ net45 sg13g2_a221oi_1
XFILLER_6_32 VPWR VGND sg13g2_decap_8
X_1572_ VGND VPWR net131 daisychain\[6\] _0537_ net38 sg13g2_a21oi_1
XFILLER_3_291 VPWR VGND sg13g2_decap_8
X_2124_ _0933_ net121 state\[35\] VPWR VGND sg13g2_nand2_1
X_2055_ VGND VPWR _0514_ _0898_ _0384_ net82 sg13g2_a21oi_1
XFILLER_34_151 VPWR VGND sg13g2_decap_8
XFILLER_22_368 VPWR VGND sg13g2_decap_8
X_1908_ VGND VPWR net155 daisychain\[90\] _0789_ net61 sg13g2_a21oi_1
X_1839_ net201 _0227_ _0736_ _0737_ VPWR VGND sg13g2_a21o_1
X_2528__284 VPWR VGND net283 sg13g2_tiehi
XFILLER_2_729 VPWR VGND sg13g2_fill_1
XFILLER_1_217 VPWR VGND sg13g2_decap_8
XFILLER_46_939 VPWR VGND sg13g2_fill_2
XFILLER_45_449 VPWR VGND sg13g2_fill_2
XFILLER_26_652 VPWR VGND sg13g2_fill_2
XFILLER_25_151 VPWR VGND sg13g2_decap_8
XFILLER_13_368 VPWR VGND sg13g2_decap_8
XFILLER_15_74 VPWR VGND sg13g2_decap_8
XFILLER_40_154 VPWR VGND sg13g2_decap_8
XFILLER_5_545 VPWR VGND sg13g2_decap_8
XFILLER_31_95 VPWR VGND sg13g2_decap_8
XFILLER_49_700 VPWR VGND sg13g2_fill_1
XFILLER_49_733 VPWR VGND sg13g2_fill_2
XFILLER_49_722 VPWR VGND sg13g2_decap_8
XFILLER_48_210 VPWR VGND sg13g2_decap_8
XFILLER_0_294 VPWR VGND sg13g2_decap_8
XFILLER_49_766 VPWR VGND sg13g2_decap_8
XFILLER_49_788 VPWR VGND sg13g2_fill_1
XFILLER_48_287 VPWR VGND sg13g2_decap_8
XFILLER_36_449 VPWR VGND sg13g2_decap_8
XFILLER_32_633 VPWR VGND sg13g2_fill_2
XFILLER_16_151 VPWR VGND sg13g2_decap_8
XFILLER_31_165 VPWR VGND sg13g2_decap_8
XFILLER_8_361 VPWR VGND sg13g2_decap_8
X_1624_ VGND VPWR net139 daisychain\[19\] _0576_ net46 sg13g2_a21oi_1
X_1555_ net177 _0189_ _0523_ _0524_ VPWR VGND sg13g2_a21o_1
X_1486_ VPWR _0204_ daisychain\[53\] VGND sg13g2_inv_1
XFILLER_39_210 VPWR VGND sg13g2_decap_8
X_2107_ VGND VPWR _0593_ _0924_ _0410_ net79 sg13g2_a21oi_1
XFILLER_39_287 VPWR VGND sg13g2_decap_8
XFILLER_27_438 VPWR VGND sg13g2_decap_4
X_2038_ net209 VPWR _0886_ VGND state\[124\] net166 sg13g2_o21ai_1
XFILLER_10_305 VPWR VGND sg13g2_decap_8
XFILLER_23_688 VPWR VGND sg13g2_fill_1
XFILLER_22_165 VPWR VGND sg13g2_decap_8
X_2465__382 VPWR VGND net381 sg13g2_tiehi
XFILLER_2_537 VPWR VGND sg13g2_decap_8
XFILLER_46_747 VPWR VGND sg13g2_fill_2
XFILLER_45_224 VPWR VGND sg13g2_decap_8
XFILLER_26_460 VPWR VGND sg13g2_decap_4
XFILLER_26_95 VPWR VGND sg13g2_decap_8
XFILLER_13_165 VPWR VGND sg13g2_decap_8
XFILLER_9_158 VPWR VGND sg13g2_decap_8
X_2444__466 VPWR VGND net465 sg13g2_tiehi
XFILLER_5_375 VPWR VGND sg13g2_decap_8
XFILLER_47_7 VPWR VGND sg13g2_decap_8
X_1340_ VPWR _0096_ state\[71\] VGND sg13g2_inv_1
XFILLER_3_11 VPWR VGND sg13g2_decap_8
XFILLER_3_88 VPWR VGND sg13g2_decap_8
XFILLER_1_581 VPWR VGND sg13g2_decap_8
XFILLER_36_224 VPWR VGND sg13g2_decap_8
XFILLER_32_441 VPWR VGND sg13g2_fill_1
X_2414__281 VPWR VGND net280 sg13g2_tiehi
XFILLER_20_625 VPWR VGND sg13g2_fill_1
XFILLER_20_614 VPWR VGND sg13g2_decap_8
XFILLER_32_485 VPWR VGND sg13g2_decap_8
XFILLER_20_658 VPWR VGND sg13g2_decap_8
Xclkbuf_leaf_8_clk clknet_2_3__leaf_clk clknet_leaf_8_clk VPWR VGND sg13g2_buf_8
X_1607_ net171 _0163_ _0562_ _0563_ VPWR VGND sg13g2_a21o_1
Xfanout104 net105 net104 VPWR VGND sg13g2_buf_1
Xfanout137 net146 net137 VPWR VGND sg13g2_buf_1
Xfanout126 net127 net126 VPWR VGND sg13g2_buf_1
Xfanout115 _0512_ net115 VPWR VGND sg13g2_buf_1
XdigitalenL.g\[3\].u.inv2 VPWR digitalenL.g\[3\].u.OUTP digitalenL.g\[3\].u.OUTN VGND
+ sg13g2_inv_1
X_1538_ VPWR _0167_ daisychain\[1\] VGND sg13g2_inv_1
Xfanout159 net162 net159 VPWR VGND sg13g2_buf_1
Xfanout148 net150 net148 VPWR VGND sg13g2_buf_1
X_1469_ VPWR _0223_ daisychain\[70\] VGND sg13g2_inv_1
XFILLER_47_28 VPWR VGND sg13g2_decap_8
XFILLER_27_224 VPWR VGND sg13g2_decap_8
XFILLER_24_920 VPWR VGND sg13g2_fill_1
XFILLER_15_419 VPWR VGND sg13g2_decap_4
XFILLER_42_238 VPWR VGND sg13g2_decap_8
XFILLER_23_441 VPWR VGND sg13g2_decap_8
XFILLER_23_474 VPWR VGND sg13g2_decap_8
XFILLER_10_102 VPWR VGND sg13g2_decap_8
XFILLER_11_636 VPWR VGND sg13g2_decap_8
XFILLER_11_647 VPWR VGND sg13g2_fill_1
XFILLER_10_179 VPWR VGND sg13g2_decap_8
XFILLER_12_53 VPWR VGND sg13g2_decap_8
XFILLER_3_824 VPWR VGND sg13g2_fill_1
XFILLER_2_312 VPWR VGND sg13g2_decap_8
XFILLER_18_235 VPWR VGND sg13g2_decap_8
XFILLER_33_249 VPWR VGND sg13g2_decap_8
XFILLER_14_485 VPWR VGND sg13g2_decap_8
X_2510_ net427 VGND VPWR _0456_ state\[72\] clknet_leaf_11_clk sg13g2_dfrbpq_1
X_2441_ net477 VGND VPWR _0387_ state\[3\] clknet_leaf_2_clk sg13g2_dfrbpq_1
XFILLER_6_695 VPWR VGND sg13g2_fill_1
XFILLER_5_172 VPWR VGND sg13g2_decap_8
X_2372_ net364 VGND VPWR _0318_ daisychain\[62\] clknet_leaf_13_clk sg13g2_dfrbpq_1
X_2479__326 VPWR VGND net325 sg13g2_tiehi
X_1323_ VPWR _0114_ state\[88\] VGND sg13g2_inv_1
XFILLER_49_382 VPWR VGND sg13g2_decap_8
XFILLER_37_566 VPWR VGND sg13g2_decap_4
XFILLER_40_709 VPWR VGND sg13g2_fill_1
XFILLER_24_249 VPWR VGND sg13g2_decap_8
XFILLER_21_901 VPWR VGND sg13g2_fill_1
XFILLER_20_411 VPWR VGND sg13g2_decap_8
X_2347__415 VPWR VGND net414 sg13g2_tiehi
XFILLER_3_109 VPWR VGND sg13g2_decap_8
XFILLER_0_849 VPWR VGND sg13g2_decap_8
XFILLER_47_308 VPWR VGND sg13g2_decap_8
XFILLER_28_566 VPWR VGND sg13g2_fill_2
XFILLER_15_249 VPWR VGND sg13g2_decap_8
XFILLER_11_466 VPWR VGND sg13g2_decap_8
XFILLER_7_437 VPWR VGND sg13g2_decap_8
XFILLER_23_74 VPWR VGND sg13g2_decap_8
XFILLER_3_654 VPWR VGND sg13g2_decap_4
X_2398__313 VPWR VGND net312 sg13g2_tiehi
XFILLER_2_186 VPWR VGND sg13g2_decap_8
XFILLER_38_308 VPWR VGND sg13g2_decap_8
XFILLER_47_820 VPWR VGND sg13g2_fill_1
XFILLER_0_56 VPWR VGND sg13g2_decap_8
XFILLER_46_385 VPWR VGND sg13g2_decap_8
X_1941_ VPWR VGND _0813_ net96 _0812_ _0254_ _0355_ net48 sg13g2_a221oi_1
XFILLER_9_32 VPWR VGND sg13g2_decap_8
X_1872_ VGND VPWR net154 daisychain\[81\] _0762_ net59 sg13g2_a21oi_1
X_2424_ net260 VGND VPWR _0370_ daisychain\[114\] clknet_leaf_3_clk sg13g2_dfrbpq_1
X_2355_ net398 VGND VPWR _0301_ daisychain\[45\] clknet_leaf_15_clk sg13g2_dfrbpq_1
XFILLER_36_0 VPWR VGND sg13g2_decap_8
X_1306_ VPWR _0006_ state\[105\] VGND sg13g2_inv_1
XFILLER_29_319 VPWR VGND sg13g2_decap_8
X_2286_ _1014_ net136 state\[116\] VPWR VGND sg13g2_nand2_1
XFILLER_40_539 VPWR VGND sg13g2_fill_1
XFILLER_20_263 VPWR VGND sg13g2_decap_8
XFILLER_0_602 VPWR VGND sg13g2_decap_8
XFILLER_47_105 VPWR VGND sg13g2_decap_8
XFILLER_44_801 VPWR VGND sg13g2_fill_1
XFILLER_18_74 VPWR VGND sg13g2_decap_8
XFILLER_43_322 VPWR VGND sg13g2_decap_8
XFILLER_8_702 VPWR VGND sg13g2_decap_8
XFILLER_34_95 VPWR VGND sg13g2_decap_8
XFILLER_11_263 VPWR VGND sg13g2_decap_8
XFILLER_7_245 VPWR VGND sg13g2_decap_8
XFILLER_4_963 VPWR VGND sg13g2_fill_2
XFILLER_4_952 VPWR VGND sg13g2_decap_8
XFILLER_4_996 VPWR VGND sg13g2_decap_8
XFILLER_3_473 VPWR VGND sg13g2_decap_8
X_2140_ _0941_ net123 state\[43\] VPWR VGND sg13g2_nand2_1
XFILLER_38_105 VPWR VGND sg13g2_decap_8
X_2071_ VGND VPWR _0539_ _0906_ _0392_ net71 sg13g2_a21oi_1
XFILLER_47_661 VPWR VGND sg13g2_fill_2
XFILLER_46_182 VPWR VGND sg13g2_decap_8
XFILLER_34_333 VPWR VGND sg13g2_decap_8
X_1924_ VGND VPWR net142 daisychain\[94\] _0801_ net48 sg13g2_a21oi_1
X_1855_ net204 _0231_ _0748_ _0749_ VPWR VGND sg13g2_a21o_1
X_1786_ net227 VPWR _0697_ VGND state\[61\] net197 sg13g2_o21ai_1
X_2407_ net294 VGND VPWR _0353_ daisychain\[97\] clknet_leaf_5_clk sg13g2_dfrbpq_1
X_2338_ net432 VGND VPWR _0284_ daisychain\[28\] clknet_leaf_17_clk sg13g2_dfrbpq_1
XFILLER_29_116 VPWR VGND sg13g2_decap_8
X_2269_ VGND VPWR _0836_ _1005_ _0491_ net87 sg13g2_a21oi_1
XFILLER_44_119 VPWR VGND sg13g2_decap_8
XFILLER_37_182 VPWR VGND sg13g2_decap_8
XFILLER_25_333 VPWR VGND sg13g2_decap_8
XFILLER_40_336 VPWR VGND sg13g2_decap_8
XFILLER_21_583 VPWR VGND sg13g2_fill_2
XFILLER_21_572 VPWR VGND sg13g2_fill_2
XFILLER_5_738 VPWR VGND sg13g2_decap_8
XFILLER_20_53 VPWR VGND sg13g2_decap_8
XFILLER_49_904 VPWR VGND sg13g2_fill_1
XFILLER_0_476 VPWR VGND sg13g2_decap_8
XFILLER_48_436 VPWR VGND sg13g2_decap_8
XFILLER_29_95 VPWR VGND sg13g2_decap_8
XFILLER_35_119 VPWR VGND sg13g2_decap_8
XFILLER_28_193 VPWR VGND sg13g2_decap_8
XFILLER_16_333 VPWR VGND sg13g2_decap_8
XFILLER_43_196 VPWR VGND sg13g2_decap_8
XFILLER_31_347 VPWR VGND sg13g2_decap_8
XFILLER_12_561 VPWR VGND sg13g2_decap_8
XFILLER_12_572 VPWR VGND sg13g2_fill_2
X_1640_ VGND VPWR net140 daisychain\[23\] _0588_ net45 sg13g2_a21oi_1
XFILLER_8_576 VPWR VGND sg13g2_decap_8
XFILLER_6_11 VPWR VGND sg13g2_decap_8
XANTENNA_4 VPWR VGND _0163_ sg13g2_antennanp
X_1571_ net183 _0233_ _0535_ _0536_ VPWR VGND sg13g2_a21o_1
XFILLER_6_88 VPWR VGND sg13g2_decap_8
XFILLER_4_793 VPWR VGND sg13g2_decap_4
XFILLER_3_270 VPWR VGND sg13g2_decap_8
X_2123_ VGND VPWR _0617_ _0932_ _0418_ net76 sg13g2_a21oi_1
X_2054_ _0898_ net129 state\[0\] VPWR VGND sg13g2_nand2_1
XFILLER_35_653 VPWR VGND sg13g2_fill_1
XFILLER_34_130 VPWR VGND sg13g2_decap_8
XFILLER_19_193 VPWR VGND sg13g2_decap_8
XFILLER_22_347 VPWR VGND sg13g2_decap_8
X_1907_ net203 _0246_ _0787_ _0788_ VPWR VGND sg13g2_a21o_1
X_1838_ net229 VPWR _0736_ VGND state\[74\] net201 sg13g2_o21ai_1
X_1769_ VPWR VGND _0684_ net105 _0683_ _0207_ _0312_ net56 sg13g2_a221oi_1
X_2424__261 VPWR VGND net260 sg13g2_tiehi
XFILLER_46_918 VPWR VGND sg13g2_fill_2
XFILLER_18_609 VPWR VGND sg13g2_decap_8
XFILLER_46_929 VPWR VGND sg13g2_fill_1
XFILLER_45_406 VPWR VGND sg13g2_decap_8
XFILLER_17_119 VPWR VGND sg13g2_decap_8
XFILLER_25_130 VPWR VGND sg13g2_decap_8
X_2355__399 VPWR VGND net398 sg13g2_tiehi
XFILLER_13_347 VPWR VGND sg13g2_decap_8
XFILLER_41_656 VPWR VGND sg13g2_decap_8
XFILLER_40_133 VPWR VGND sg13g2_decap_8
XFILLER_15_53 VPWR VGND sg13g2_decap_8
XFILLER_5_524 VPWR VGND sg13g2_decap_8
XFILLER_31_74 VPWR VGND sg13g2_decap_8
XFILLER_0_273 VPWR VGND sg13g2_decap_8
XFILLER_48_266 VPWR VGND sg13g2_decap_8
XFILLER_36_428 VPWR VGND sg13g2_fill_1
XFILLER_17_653 VPWR VGND sg13g2_decap_8
XFILLER_16_130 VPWR VGND sg13g2_decap_8
XFILLER_32_623 VPWR VGND sg13g2_fill_1
XFILLER_32_601 VPWR VGND sg13g2_fill_1
XFILLER_31_144 VPWR VGND sg13g2_decap_8
XFILLER_8_340 VPWR VGND sg13g2_decap_8
X_1623_ net183 _0168_ _0574_ _0575_ VPWR VGND sg13g2_a21o_1
X_1554_ net216 VPWR _0523_ VGND state\[3\] net177 sg13g2_o21ai_1
X_1485_ VPWR _0205_ daisychain\[54\] VGND sg13g2_inv_1
.ends
