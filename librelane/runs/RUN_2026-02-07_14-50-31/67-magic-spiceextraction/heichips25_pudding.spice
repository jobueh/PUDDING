* NGSPICE file created from heichips25_pudding.ext - technology: ihp-sg13g2

* Black-box entry subcircuit for sg13g2_decap_8 abstract view
.subckt sg13g2_decap_8 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_inv_1 abstract view
.subckt sg13g2_inv_1 VDD Y A VSS
.ends

* Black-box entry subcircuit for sg13g2_fill_1 abstract view
.subckt sg13g2_fill_1 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_fill_2 abstract view
.subckt sg13g2_fill_2 VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_buf_1 abstract view
.subckt sg13g2_buf_1 A X VDD VSS
.ends

* Black-box entry subcircuit for sg13g2_decap_4 abstract view
.subckt sg13g2_decap_4 VDD VSS
.ends

* Black-box entry subcircuit for dac128module abstract view
.subckt dac128module ON[64] ONB[64] ON[65] ONB[65] ON[66] ONB[66] ON[67] ONB[67] ON[68]
+ ONB[68] ON[69] ONB[69] ON[70] ONB[70] ON[71] ONB[71] ON[72] ONB[72] EN[2] ENB[2]
+ ON[73] ONB[73] ON[74] ONB[74] ON[75] ONB[75] ON[76] ONB[76] ON[77] ONB[77] ON[78]
+ ONB[78] ON[79] ONB[79] ON[80] ONB[80] ON[81] ONB[81] ON[82] ONB[82] ON[83] ONB[83]
+ ON[84] ONB[84] ON[85] ONB[85] ON[86] ONB[86] ON[87] ONB[87] ON[88] ONB[88] ON[89]
+ ONB[89] ON[90] ONB[90] ON[91] ONB[91] ON[92] ONB[92] ON[93] ONB[93] ON[94] ONB[94]
+ ON[95] ONB[95] ON[96] ONB[96] ON[97] ONB[97] ON[98] ONB[98] ON[99] ONB[99] ON[100]
+ ONB[100] ON[101] ONB[101] ON[102] ONB[102] ON[103] ONB[103] ON[104] ONB[104] ON[105]
+ ONB[105] ON[106] ONB[106] ON[107] ONB[107] ON[108] ONB[108] ON[109] ONB[109] ON[110]
+ ONB[110] ON[111] ONB[111] ON[112] ONB[112] ON[113] ONB[113] ON[114] ONB[114] ON[115]
+ ONB[115] ON[116] ONB[116] ON[117] ONB[117] ON[118] ONB[118] ON[119] ONB[119] ON[120]
+ ONB[120] ON[121] ONB[121] ON[122] ONB[122] EN[3] ENB[3] ON[123] ONB[123] ON[124]
+ ONB[124] ON[125] ONB[125] ON[126] ONB[126] ON[127] ONB[127] ON[0] ONB[0] ON[1] ONB[1]
+ ON[2] ONB[2] ON[3] ONB[3] ON[4] ONB[4] ON[5] ONB[5] ON[6] EN[0] ENB[0] ONB[6] ON[7]
+ ONB[7] ON[8] ONB[8] ON[9] ONB[9] ON[10] ONB[10] ON[11] ONB[11] ON[12] ONB[12] ON[13]
+ ONB[13] ON[14] ONB[14] ON[15] ONB[15] ON[16] ONB[16] ON[17] ONB[17] ON[18] ONB[18]
+ ON[19] ONB[19] ON[20] ONB[20] ON[21] ONB[21] ON[22] ONB[22] ON[23] ONB[23] ON[24]
+ ONB[24] ON[25] ONB[25] ON[26] ONB[26] ON[27] ONB[27] ON[28] ONB[28] ON[29] ONB[29]
+ ON[30] ONB[30] ON[31] ONB[31] ON[33] ONB[33] ON[32] ONB[32] ON[34] ONB[34] ON[35]
+ ONB[35] ON[36] ONB[36] ON[37] ONB[37] ON[38] ONB[38] ON[39] ONB[39] ON[40] ONB[40]
+ ON[41] ONB[41] ON[42] ONB[42] ON[43] ONB[43] ON[44] ONB[44] ON[45] ONB[45] ON[46]
+ ONB[46] ON[47] ONB[47] ON[48] ONB[48] ON[49] ONB[49] ON[50] ONB[50] ON[51] ONB[51]
+ ON[52] ONB[52] ON[53] ONB[53] ON[54] ONB[54] ON[55] ONB[55] ON[56] ONB[56] ON[57]
+ ONB[57] ON[58] ONB[58] ON[59] ONB[59] ON[60] ONB[60] ON[61] ONB[61] ON[62] ONB[62]
+ ON[63] ONB[63] EN[1] ENB[1] VSS VDD
.ends

* Black-box entry subcircuit for sg13g2_tiehi abstract view
.subckt sg13g2_tiehi VDD VSS L_HI
.ends

.subckt heichips25_pudding VGND VPWR clk ena rst_n ui_in[0] ui_in[1] ui_in[2] ui_in[3]
+ ui_in[4] ui_in[5] ui_in[6] ui_in[7] uio_in[0] uio_in[1] uio_in[2] uio_in[3] uio_in[4]
+ uio_in[5] uio_in[6] uio_in[7] uio_oe[0] uio_oe[1] uio_oe[2] uio_oe[3] uio_oe[4]
+ uio_oe[5] uio_oe[6] uio_oe[7] uio_out[0] uio_out[1] uio_out[2] uio_out[3] uio_out[4]
+ uio_out[5] uio_out[6] uio_out[7] uo_out[0] uo_out[1] uo_out[2] uo_out[3] uo_out[4]
+ uo_out[5] uo_out[6] uo_out[7]
XFILLER_28_907 VPWR VGND sg13g2_decap_8
XFILLER_39_266 VPWR VGND sg13g2_decap_8
XFILLER_27_406 VPWR VGND sg13g2_decap_8
XFILLER_35_483 VPWR VGND sg13g2_decap_8
XFILLER_23_634 VPWR VGND sg13g2_decap_8
XFILLER_10_306 VPWR VGND sg13g2_decap_8
XFILLER_22_144 VPWR VGND sg13g2_decap_8
XFILLER_2_505 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[2\].u.inv VPWR digitalenH.g\[2\].u.OUTN net4 VGND sg13g2_inv_1
XFILLER_45_203 VPWR VGND sg13g2_decap_8
XFILLER_18_428 VPWR VGND sg13g2_decap_8
XFILLER_27_973 VPWR VGND sg13g2_decap_8
XFILLER_26_74 VPWR VGND sg13g2_decap_8
XFILLER_14_645 VPWR VGND sg13g2_decap_8
XFILLER_42_954 VPWR VGND sg13g2_fill_1
XFILLER_41_420 VPWR VGND sg13g2_decap_8
XFILLER_26_494 VPWR VGND sg13g2_decap_8
XFILLER_13_155 VPWR VGND sg13g2_decap_8
XFILLER_9_148 VPWR VGND sg13g2_decap_8
XFILLER_41_497 VPWR VGND sg13g2_decap_8
XFILLER_42_84 VPWR VGND sg13g2_decap_8
XFILLER_6_844 VPWR VGND sg13g2_decap_8
XFILLER_5_365 VPWR VGND sg13g2_decap_8
XdigitalL.g\[50\].u.inv VPWR digitalL.g\[50\].u.OUTN net102 VGND sg13g2_inv_1
XFILLER_1_560 VPWR VGND sg13g2_decap_8
XFILLER_3_78 VPWR VGND sg13g2_decap_8
XFILLER_49_553 VPWR VGND sg13g2_decap_8
XFILLER_36_203 VPWR VGND sg13g2_decap_8
XFILLER_18_973 VPWR VGND sg13g2_fill_2
XFILLER_18_940 VPWR VGND sg13g2_fill_2
XFILLER_45_770 VPWR VGND sg13g2_decap_8
XFILLER_18_995 VPWR VGND sg13g2_fill_2
XFILLER_44_280 VPWR VGND sg13g2_decap_8
XFILLER_32_431 VPWR VGND sg13g2_decap_8
XFILLER_20_648 VPWR VGND sg13g2_decap_8
Xfanout105 net106 net105 VPWR VGND sg13g2_buf_1
XdigitalL.g\[78\].u.buff net107 digitalL.g\[78\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_28_704 VPWR VGND sg13g2_decap_8
XdigitalH.g\[95\].u.inv VPWR digitalH.g\[95\].u.OUTN net42 VGND sg13g2_inv_1
XFILLER_27_203 VPWR VGND sg13g2_decap_8
XFILLER_43_707 VPWR VGND sg13g2_decap_8
XFILLER_42_217 VPWR VGND sg13g2_decap_8
XFILLER_24_921 VPWR VGND sg13g2_decap_8
XFILLER_35_280 VPWR VGND sg13g2_decap_8
XFILLER_23_431 VPWR VGND sg13g2_decap_8
XFILLER_24_998 VPWR VGND sg13g2_decap_8
XFILLER_10_103 VPWR VGND sg13g2_decap_8
XFILLER_11_659 VPWR VGND sg13g2_decap_8
XFILLER_12_32 VPWR VGND sg13g2_decap_8
XFILLER_2_302 VPWR VGND sg13g2_decap_8
XFILLER_3_869 VPWR VGND sg13g2_decap_8
XFILLER_2_379 VPWR VGND sg13g2_decap_8
XFILLER_19_737 VPWR VGND sg13g2_decap_8
XFILLER_18_225 VPWR VGND sg13g2_decap_8
XFILLER_46_567 VPWR VGND sg13g2_decap_8
XFILLER_37_84 VPWR VGND sg13g2_decap_8
XFILLER_34_707 VPWR VGND sg13g2_decap_8
XFILLER_33_217 VPWR VGND sg13g2_decap_8
XFILLER_27_770 VPWR VGND sg13g2_decap_8
XFILLER_26_291 VPWR VGND sg13g2_decap_8
XFILLER_14_442 VPWR VGND sg13g2_decap_8
XdigitalH.g\[106\].u.inv VPWR digitalH.g\[106\].u.OUTN net39 VGND sg13g2_inv_1
XFILLER_30_902 VPWR VGND sg13g2_decap_8
XFILLER_41_294 VPWR VGND sg13g2_decap_8
XFILLER_30_968 VPWR VGND sg13g2_decap_8
XFILLER_10_670 VPWR VGND sg13g2_decap_8
XFILLER_6_652 VPWR VGND sg13g2_decap_8
XFILLER_5_162 VPWR VGND sg13g2_decap_8
XFILLER_25_1019 VPWR VGND sg13g2_decap_8
XFILLER_49_350 VPWR VGND sg13g2_decap_8
XFILLER_37_567 VPWR VGND sg13g2_decap_8
XFILLER_25_718 VPWR VGND sg13g2_decap_8
XFILLER_24_228 VPWR VGND sg13g2_decap_8
XFILLER_21_913 VPWR VGND sg13g2_decap_8
XFILLER_20_445 VPWR VGND sg13g2_decap_8
XFILLER_28_501 VPWR VGND sg13g2_decap_8
XdigitalH.g\[69\].u.buff net62 digitalH.g\[69\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_504 VPWR VGND sg13g2_decap_8
XFILLER_28_578 VPWR VGND sg13g2_decap_8
XFILLER_15_239 VPWR VGND sg13g2_decap_8
XFILLER_24_795 VPWR VGND sg13g2_decap_8
XFILLER_11_456 VPWR VGND sg13g2_decap_8
XFILLER_23_53 VPWR VGND sg13g2_decap_8
XFILLER_7_449 VPWR VGND sg13g2_decap_8
XFILLER_48_1008 VPWR VGND sg13g2_decap_8
XFILLER_3_666 VPWR VGND sg13g2_decap_8
XFILLER_2_176 VPWR VGND sg13g2_decap_8
XFILLER_0_35 VPWR VGND sg13g2_decap_8
XFILLER_47_854 VPWR VGND sg13g2_decap_8
XFILLER_19_534 VPWR VGND sg13g2_decap_8
XFILLER_46_364 VPWR VGND sg13g2_decap_8
XFILLER_34_504 VPWR VGND sg13g2_decap_8
XFILLER_9_22 VPWR VGND sg13g2_decap_8
XFILLER_42_581 VPWR VGND sg13g2_decap_8
XFILLER_30_732 VPWR VGND sg13g2_decap_8
XFILLER_9_99 VPWR VGND sg13g2_decap_8
XdigitalH.g\[43\].u.inv VPWR digitalH.g\[43\].u.OUTN net47 VGND sg13g2_inv_1
XFILLER_30_798 VPWR VGND sg13g2_fill_2
XFILLER_7_994 VPWR VGND sg13g2_fill_1
XFILLER_37_364 VPWR VGND sg13g2_decap_8
XFILLER_25_515 VPWR VGND sg13g2_decap_8
XFILLER_40_518 VPWR VGND sg13g2_decap_8
XFILLER_33_581 VPWR VGND sg13g2_decap_8
XFILLER_21_732 VPWR VGND sg13g2_decap_8
XFILLER_20_242 VPWR VGND sg13g2_decap_8
XdigitalL.g\[93\].u.buff net97 digitalL.g\[93\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[22\].u.buff net81 digitalL.g\[22\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_0_658 VPWR VGND sg13g2_decap_8
XdigitalL.g\[97\].u.inv VPWR digitalL.g\[97\].u.OUTN net89 VGND sg13g2_inv_1
XFILLER_29_865 VPWR VGND sg13g2_decap_8
XFILLER_44_824 VPWR VGND sg13g2_fill_1
XFILLER_43_301 VPWR VGND sg13g2_decap_8
XFILLER_28_375 VPWR VGND sg13g2_decap_8
XFILLER_18_64 VPWR VGND sg13g2_decap_8
XFILLER_16_526 VPWR VGND sg13g2_decap_8
XdigitalH.g\[116\].u.buff net36 digitalH.g\[116\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_44_857 VPWR VGND sg13g2_decap_8
XFILLER_43_378 VPWR VGND sg13g2_decap_8
XFILLER_34_63 VPWR VGND sg13g2_decap_8
XFILLER_31_529 VPWR VGND sg13g2_decap_8
XFILLER_12_732 VPWR VGND sg13g2_decap_8
XFILLER_24_592 VPWR VGND sg13g2_decap_8
XFILLER_11_253 VPWR VGND sg13g2_decap_8
XFILLER_8_736 VPWR VGND sg13g2_decap_4
XFILLER_7_246 VPWR VGND sg13g2_decap_8
XFILLER_4_953 VPWR VGND sg13g2_decap_8
XFILLER_3_463 VPWR VGND sg13g2_decap_8
XFILLER_19_331 VPWR VGND sg13g2_decap_8
XFILLER_47_651 VPWR VGND sg13g2_decap_8
XFILLER_46_161 VPWR VGND sg13g2_decap_8
XFILLER_34_301 VPWR VGND sg13g2_decap_8
XFILLER_34_378 VPWR VGND sg13g2_decap_8
XFILLER_22_529 VPWR VGND sg13g2_decap_8
XFILLER_38_651 VPWR VGND sg13g2_decap_8
XFILLER_26_802 VPWR VGND sg13g2_decap_8
XFILLER_37_161 VPWR VGND sg13g2_decap_8
XFILLER_25_312 VPWR VGND sg13g2_decap_8
XFILLER_26_879 VPWR VGND sg13g2_decap_8
XFILLER_40_315 VPWR VGND sg13g2_decap_8
XFILLER_25_389 VPWR VGND sg13g2_decap_8
XdigitalL.g\[106\].u.buff net86 digitalL.g\[106\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_32 VPWR VGND sg13g2_decap_8
XFILLER_1_945 VPWR VGND sg13g2_decap_8
XFILLER_0_455 VPWR VGND sg13g2_decap_8
XdigitalH.g\[84\].u.buff net57 digitalH.g\[84\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_49_938 VPWR VGND sg13g2_decap_8
XdigitalH.g\[13\].u.buff net27 digitalH.g\[13\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_448 VPWR VGND sg13g2_decap_8
XFILLER_29_74 VPWR VGND sg13g2_decap_8
XFILLER_21_1011 VPWR VGND sg13g2_decap_8
XFILLER_29_662 VPWR VGND sg13g2_decap_8
XFILLER_16_323 VPWR VGND sg13g2_decap_8
XFILLER_28_172 VPWR VGND sg13g2_decap_8
XFILLER_44_665 VPWR VGND sg13g2_decap_8
XFILLER_32_816 VPWR VGND sg13g2_fill_1
XFILLER_45_84 VPWR VGND sg13g2_decap_8
XFILLER_43_175 VPWR VGND sg13g2_decap_8
XFILLER_32_849 VPWR VGND sg13g2_fill_1
XFILLER_32_838 VPWR VGND sg13g2_decap_4
XFILLER_31_326 VPWR VGND sg13g2_decap_8
XFILLER_8_533 VPWR VGND sg13g2_decap_8
XFILLER_4_750 VPWR VGND sg13g2_decap_8
XFILLER_6_78 VPWR VGND sg13g2_decap_8
XFILLER_3_260 VPWR VGND sg13g2_decap_8
XFILLER_20_4 VPWR VGND sg13g2_decap_8
XFILLER_39_448 VPWR VGND sg13g2_decap_8
XFILLER_26_109 VPWR VGND sg13g2_decap_8
XFILLER_35_665 VPWR VGND sg13g2_decap_8
XFILLER_34_175 VPWR VGND sg13g2_decap_8
XFILLER_23_816 VPWR VGND sg13g2_decap_8
XFILLER_22_326 VPWR VGND sg13g2_decap_8
XdigitalL.g\[45\].u.inv VPWR digitalL.g\[45\].u.OUTN net95 VGND sg13g2_inv_1
XFILLER_44_1011 VPWR VGND sg13g2_decap_8
XFILLER_41_602 VPWR VGND sg13g2_decap_8
XFILLER_26_676 VPWR VGND sg13g2_decap_8
XFILLER_13_337 VPWR VGND sg13g2_decap_8
XFILLER_15_43 VPWR VGND sg13g2_decap_8
XFILLER_40_112 VPWR VGND sg13g2_decap_8
XFILLER_25_186 VPWR VGND sg13g2_decap_8
XFILLER_41_679 VPWR VGND sg13g2_decap_8
XFILLER_40_189 VPWR VGND sg13g2_decap_8
XFILLER_22_893 VPWR VGND sg13g2_decap_8
XFILLER_31_53 VPWR VGND sg13g2_decap_8
XFILLER_5_547 VPWR VGND sg13g2_decap_8
Xoutput20 net20 uo_out[7] VPWR VGND sg13g2_buf_1
Xoutput7 net7 uio_out[2] VPWR VGND sg13g2_buf_1
XFILLER_1_742 VPWR VGND sg13g2_decap_8
XFILLER_0_252 VPWR VGND sg13g2_decap_8
XFILLER_49_735 VPWR VGND sg13g2_decap_8
XFILLER_48_245 VPWR VGND sg13g2_decap_8
XFILLER_17_610 VPWR VGND sg13g2_decap_8
XFILLER_16_120 VPWR VGND sg13g2_decap_8
XFILLER_45_952 VPWR VGND sg13g2_decap_8
XFILLER_17_687 VPWR VGND sg13g2_decap_8
XFILLER_44_462 VPWR VGND sg13g2_decap_8
XFILLER_32_613 VPWR VGND sg13g2_decap_8
XFILLER_16_197 VPWR VGND sg13g2_decap_8
XFILLER_31_123 VPWR VGND sg13g2_decap_8
XFILLER_8_330 VPWR VGND sg13g2_decap_8
XFILLER_28_1028 VPWR VGND sg13g2_fill_1
XFILLER_39_245 VPWR VGND sg13g2_decap_8
XFILLER_35_462 VPWR VGND sg13g2_decap_8
XFILLER_23_613 VPWR VGND sg13g2_decap_8
XFILLER_22_123 VPWR VGND sg13g2_decap_8
XFILLER_31_690 VPWR VGND sg13g2_decap_8
XdigitalH.g\[91\].u.inv VPWR digitalH.g\[91\].u.OUTN net55 VGND sg13g2_inv_1
XFILLER_7_8 VPWR VGND sg13g2_decap_8
XFILLER_18_407 VPWR VGND sg13g2_decap_8
XFILLER_46_749 VPWR VGND sg13g2_decap_8
XFILLER_45_259 VPWR VGND sg13g2_decap_8
XFILLER_27_952 VPWR VGND sg13g2_decap_8
XFILLER_26_53 VPWR VGND sg13g2_decap_8
XFILLER_26_473 VPWR VGND sg13g2_decap_8
XFILLER_14_624 VPWR VGND sg13g2_decap_8
XFILLER_13_134 VPWR VGND sg13g2_decap_8
XFILLER_41_476 VPWR VGND sg13g2_decap_8
XFILLER_9_127 VPWR VGND sg13g2_decap_8
XdigitalL.g\[121\].u.buff net76 digitalL.g\[121\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_42_63 VPWR VGND sg13g2_decap_8
XFILLER_22_690 VPWR VGND sg13g2_decap_8
XFILLER_5_344 VPWR VGND sg13g2_decap_8
XdigitalH.g\[102\].u.inv VPWR digitalH.g\[102\].u.OUTN net40 VGND sg13g2_inv_1
XFILLER_49_532 VPWR VGND sg13g2_decap_8
XFILLER_3_57 VPWR VGND sg13g2_decap_8
XFILLER_36_259 VPWR VGND sg13g2_decap_8
XFILLER_18_952 VPWR VGND sg13g2_fill_2
XFILLER_17_484 VPWR VGND sg13g2_decap_8
XFILLER_32_410 VPWR VGND sg13g2_decap_8
XFILLER_32_487 VPWR VGND sg13g2_decap_8
XFILLER_20_627 VPWR VGND sg13g2_decap_8
XFILLER_9_694 VPWR VGND sg13g2_decap_8
Xfanout106 net113 net106 VPWR VGND sg13g2_buf_1
XdigitalH.g\[38\].u.inv VPWR digitalH.g\[38\].u.OUTN net45 VGND sg13g2_inv_1
XFILLER_27_259 VPWR VGND sg13g2_decap_8
XdigitalL.g\[47\].u.buff net95 digitalL.g\[47\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_24_900 VPWR VGND sg13g2_decap_8
XFILLER_23_410 VPWR VGND sg13g2_decap_8
XFILLER_24_977 VPWR VGND sg13g2_decap_8
XFILLER_11_638 VPWR VGND sg13g2_decap_8
XFILLER_23_487 VPWR VGND sg13g2_decap_8
XFILLER_10_159 VPWR VGND sg13g2_decap_8
XFILLER_12_11 VPWR VGND sg13g2_decap_8
XFILLER_12_88 VPWR VGND sg13g2_decap_8
XFILLER_3_848 VPWR VGND sg13g2_decap_8
XFILLER_2_358 VPWR VGND sg13g2_decap_8
XFILLER_18_204 VPWR VGND sg13g2_decap_8
XFILLER_19_716 VPWR VGND sg13g2_decap_8
XFILLER_46_546 VPWR VGND sg13g2_decap_8
XFILLER_37_63 VPWR VGND sg13g2_decap_8
XFILLER_14_421 VPWR VGND sg13g2_decap_8
XFILLER_26_270 VPWR VGND sg13g2_decap_8
XFILLER_18_1016 VPWR VGND sg13g2_fill_1
XFILLER_14_498 VPWR VGND sg13g2_decap_8
XFILLER_41_273 VPWR VGND sg13g2_decap_8
XFILLER_30_947 VPWR VGND sg13g2_fill_2
XFILLER_6_631 VPWR VGND sg13g2_decap_8
XFILLER_5_141 VPWR VGND sg13g2_decap_8
XFILLER_37_546 VPWR VGND sg13g2_decap_8
XFILLER_24_207 VPWR VGND sg13g2_decap_8
XFILLER_18_771 VPWR VGND sg13g2_fill_2
XFILLER_17_281 VPWR VGND sg13g2_decap_8
XFILLER_32_284 VPWR VGND sg13g2_decap_8
XFILLER_20_424 VPWR VGND sg13g2_decap_8
XFILLER_21_969 VPWR VGND sg13g2_decap_8
XFILLER_9_491 VPWR VGND sg13g2_decap_8
XFILLER_28_557 VPWR VGND sg13g2_decap_8
XFILLER_16_708 VPWR VGND sg13g2_decap_8
XFILLER_15_218 VPWR VGND sg13g2_decap_8
XdigitalH.g\[38\].u.buff net46 digitalH.g\[38\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_24_774 VPWR VGND sg13g2_decap_8
XFILLER_11_435 VPWR VGND sg13g2_decap_8
XdigitalL.g\[93\].u.inv VPWR digitalL.g\[93\].u.OUTN net97 VGND sg13g2_inv_1
XFILLER_23_32 VPWR VGND sg13g2_decap_8
XFILLER_23_284 VPWR VGND sg13g2_decap_8
XFILLER_7_428 VPWR VGND sg13g2_decap_8
XFILLER_20_980 VPWR VGND sg13g2_decap_4
XFILLER_3_645 VPWR VGND sg13g2_decap_8
XFILLER_2_155 VPWR VGND sg13g2_decap_8
XFILLER_48_84 VPWR VGND sg13g2_decap_8
XFILLER_47_833 VPWR VGND sg13g2_decap_8
XFILLER_19_513 VPWR VGND sg13g2_decap_8
XFILLER_0_14 VPWR VGND sg13g2_decap_8
XFILLER_46_343 VPWR VGND sg13g2_decap_8
XFILLER_15_730 VPWR VGND sg13g2_fill_2
XFILLER_42_560 VPWR VGND sg13g2_decap_8
XFILLER_30_711 VPWR VGND sg13g2_decap_8
XFILLER_14_295 VPWR VGND sg13g2_decap_8
XFILLER_9_78 VPWR VGND sg13g2_decap_8
XFILLER_30_788 VPWR VGND sg13g2_decap_4
XFILLER_37_343 VPWR VGND sg13g2_decap_8
XFILLER_33_560 VPWR VGND sg13g2_decap_8
XFILLER_21_711 VPWR VGND sg13g2_decap_8
XFILLER_20_221 VPWR VGND sg13g2_decap_8
XFILLER_21_799 VPWR VGND sg13g2_decap_8
XFILLER_20_298 VPWR VGND sg13g2_decap_8
XFILLER_0_637 VPWR VGND sg13g2_decap_8
XdigitalL.g\[62\].u.buff net105 digitalL.g\[62\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_844 VPWR VGND sg13g2_decap_8
XFILLER_18_43 VPWR VGND sg13g2_decap_8
XFILLER_16_505 VPWR VGND sg13g2_decap_8
XFILLER_28_354 VPWR VGND sg13g2_decap_8
XFILLER_44_836 VPWR VGND sg13g2_decap_8
XFILLER_43_357 VPWR VGND sg13g2_decap_8
XFILLER_31_508 VPWR VGND sg13g2_decap_8
XFILLER_12_711 VPWR VGND sg13g2_decap_8
XFILLER_34_42 VPWR VGND sg13g2_decap_8
XFILLER_24_571 VPWR VGND sg13g2_decap_8
XFILLER_11_232 VPWR VGND sg13g2_decap_8
XFILLER_8_715 VPWR VGND sg13g2_decap_8
XFILLER_7_225 VPWR VGND sg13g2_decap_8
XFILLER_4_932 VPWR VGND sg13g2_decap_8
XFILLER_3_442 VPWR VGND sg13g2_decap_8
XFILLER_47_630 VPWR VGND sg13g2_decap_8
XFILLER_19_310 VPWR VGND sg13g2_decap_8
XFILLER_46_140 VPWR VGND sg13g2_decap_8
XFILLER_19_387 VPWR VGND sg13g2_decap_8
XFILLER_34_357 VPWR VGND sg13g2_decap_8
XFILLER_22_508 VPWR VGND sg13g2_decap_8
XFILLER_15_582 VPWR VGND sg13g2_decap_8
XFILLER_43_891 VPWR VGND sg13g2_fill_1
XFILLER_30_585 VPWR VGND sg13g2_decap_8
XFILLER_41_0 VPWR VGND sg13g2_decap_8
XdigitalL.g\[41\].u.inv VPWR digitalL.g\[41\].u.OUTN net94 VGND sg13g2_inv_1
XFILLER_38_630 VPWR VGND sg13g2_decap_8
XFILLER_37_140 VPWR VGND sg13g2_decap_8
XFILLER_26_858 VPWR VGND sg13g2_decap_8
XFILLER_13_519 VPWR VGND sg13g2_decap_8
XFILLER_25_368 VPWR VGND sg13g2_decap_8
XFILLER_21_585 VPWR VGND sg13g2_decap_8
XFILLER_5_729 VPWR VGND sg13g2_decap_8
XFILLER_4_239 VPWR VGND sg13g2_decap_8
XFILLER_20_11 VPWR VGND sg13g2_decap_8
XFILLER_20_88 VPWR VGND sg13g2_decap_8
XFILLER_1_924 VPWR VGND sg13g2_decap_8
XFILLER_0_434 VPWR VGND sg13g2_decap_8
XFILLER_49_917 VPWR VGND sg13g2_decap_8
XFILLER_48_427 VPWR VGND sg13g2_decap_8
XFILLER_29_53 VPWR VGND sg13g2_decap_8
XdigitalH.g\[86\].u.inv VPWR digitalH.g\[86\].u.OUTN net57 VGND sg13g2_inv_1
XFILLER_29_641 VPWR VGND sg13g2_decap_8
XFILLER_16_302 VPWR VGND sg13g2_decap_8
XdigitalH.g\[53\].u.buff net50 digitalH.g\[53\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_28_151 VPWR VGND sg13g2_decap_8
XFILLER_45_63 VPWR VGND sg13g2_decap_8
XFILLER_44_644 VPWR VGND sg13g2_decap_8
XFILLER_16_379 VPWR VGND sg13g2_decap_8
XFILLER_43_154 VPWR VGND sg13g2_decap_8
XFILLER_31_305 VPWR VGND sg13g2_decap_8
XFILLER_8_512 VPWR VGND sg13g2_decap_8
XFILLER_12_585 VPWR VGND sg13g2_decap_8
XFILLER_8_589 VPWR VGND sg13g2_decap_8
XFILLER_6_57 VPWR VGND sg13g2_decap_8
XFILLER_6_1028 VPWR VGND sg13g2_fill_1
XFILLER_39_427 VPWR VGND sg13g2_decap_8
XFILLER_48_994 VPWR VGND sg13g2_decap_8
XFILLER_35_644 VPWR VGND sg13g2_decap_8
XFILLER_19_184 VPWR VGND sg13g2_decap_8
XFILLER_34_154 VPWR VGND sg13g2_decap_8
XFILLER_22_305 VPWR VGND sg13g2_decap_8
XFILLER_30_382 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[0\].u.buff net4 digitalenH.g\[0\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_26_655 VPWR VGND sg13g2_decap_8
XFILLER_13_316 VPWR VGND sg13g2_decap_8
XFILLER_15_22 VPWR VGND sg13g2_decap_8
XFILLER_25_165 VPWR VGND sg13g2_decap_8
XFILLER_41_658 VPWR VGND sg13g2_decap_8
XFILLER_15_99 VPWR VGND sg13g2_decap_8
XFILLER_9_309 VPWR VGND sg13g2_decap_8
XFILLER_40_168 VPWR VGND sg13g2_decap_8
XFILLER_22_872 VPWR VGND sg13g2_decap_8
XFILLER_21_382 VPWR VGND sg13g2_decap_8
XFILLER_31_32 VPWR VGND sg13g2_decap_8
XFILLER_5_526 VPWR VGND sg13g2_decap_8
Xoutput10 net10 uio_out[5] VPWR VGND sg13g2_buf_1
Xoutput8 net8 uio_out[3] VPWR VGND sg13g2_buf_1
XFILLER_1_721 VPWR VGND sg13g2_decap_8
XFILLER_0_231 VPWR VGND sg13g2_decap_8
XFILLER_49_714 VPWR VGND sg13g2_decap_8
XFILLER_48_224 VPWR VGND sg13g2_decap_8
XFILLER_1_798 VPWR VGND sg13g2_decap_8
XdigitalH.g\[1\].u.buff net21 digitalH.g\[1\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_931 VPWR VGND sg13g2_decap_8
XFILLER_44_441 VPWR VGND sg13g2_decap_8
XFILLER_17_666 VPWR VGND sg13g2_decap_8
XdigitalH.g\[100\].u.buff net41 digitalH.g\[100\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_16_176 VPWR VGND sg13g2_decap_8
XFILLER_31_102 VPWR VGND sg13g2_decap_8
XFILLER_32_669 VPWR VGND sg13g2_decap_8
XFILLER_12_382 VPWR VGND sg13g2_decap_8
XFILLER_31_179 VPWR VGND sg13g2_decap_8
XFILLER_8_386 VPWR VGND sg13g2_decap_8
XFILLER_39_224 VPWR VGND sg13g2_decap_8
XFILLER_48_791 VPWR VGND sg13g2_decap_8
XFILLER_35_441 VPWR VGND sg13g2_decap_8
XFILLER_22_102 VPWR VGND sg13g2_decap_8
XFILLER_23_669 VPWR VGND sg13g2_decap_8
XFILLER_22_179 VPWR VGND sg13g2_decap_8
XdigitalH.g\[34\].u.inv VPWR digitalH.g\[34\].u.OUTN net44 VGND sg13g2_inv_1
XFILLER_46_728 VPWR VGND sg13g2_decap_8
XFILLER_45_238 VPWR VGND sg13g2_decap_8
XFILLER_27_931 VPWR VGND sg13g2_decap_8
XFILLER_26_32 VPWR VGND sg13g2_decap_8
XFILLER_14_603 VPWR VGND sg13g2_decap_8
XFILLER_26_452 VPWR VGND sg13g2_decap_8
XFILLER_13_113 VPWR VGND sg13g2_decap_8
XFILLER_9_106 VPWR VGND sg13g2_decap_8
XFILLER_41_455 VPWR VGND sg13g2_decap_8
XFILLER_42_42 VPWR VGND sg13g2_decap_8
XFILLER_5_323 VPWR VGND sg13g2_decap_8
XFILLER_6_857 VPWR VGND sg13g2_decap_8
XFILLER_3_36 VPWR VGND sg13g2_decap_8
XFILLER_49_511 VPWR VGND sg13g2_decap_8
XFILLER_1_595 VPWR VGND sg13g2_decap_8
XdigitalL.g\[88\].u.inv VPWR digitalL.g\[88\].u.OUTN net98 VGND sg13g2_inv_1
XFILLER_3_1009 VPWR VGND sg13g2_decap_8
XFILLER_49_588 VPWR VGND sg13g2_decap_8
XFILLER_37_728 VPWR VGND sg13g2_decap_8
XFILLER_18_920 VPWR VGND sg13g2_fill_1
XFILLER_36_238 VPWR VGND sg13g2_decap_8
XFILLER_17_463 VPWR VGND sg13g2_decap_8
XFILLER_18_986 VPWR VGND sg13g2_fill_1
XFILLER_32_466 VPWR VGND sg13g2_decap_8
XFILLER_20_606 VPWR VGND sg13g2_decap_8
XFILLER_13_680 VPWR VGND sg13g2_decap_8
XFILLER_9_673 VPWR VGND sg13g2_decap_8
XFILLER_8_183 VPWR VGND sg13g2_decap_8
XFILLER_5_890 VPWR VGND sg13g2_decap_8
Xfanout107 net112 net107 VPWR VGND sg13g2_buf_1
XFILLER_28_739 VPWR VGND sg13g2_decap_8
XFILLER_27_238 VPWR VGND sg13g2_decap_8
XFILLER_24_956 VPWR VGND sg13g2_decap_8
XFILLER_23_466 VPWR VGND sg13g2_decap_8
XFILLER_11_617 VPWR VGND sg13g2_decap_8
XdigitalL.g\[87\].u.buff net97 digitalL.g\[87\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_10_138 VPWR VGND sg13g2_decap_8
XdigitalL.g\[16\].u.buff net74 digitalL.g\[16\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_12_67 VPWR VGND sg13g2_decap_8
XFILLER_3_827 VPWR VGND sg13g2_decap_8
XFILLER_2_337 VPWR VGND sg13g2_decap_8
XFILLER_46_525 VPWR VGND sg13g2_decap_8
XFILLER_37_42 VPWR VGND sg13g2_decap_8
XFILLER_14_400 VPWR VGND sg13g2_decap_8
XFILLER_18_1028 VPWR VGND sg13g2_fill_1
XFILLER_42_742 VPWR VGND sg13g2_decap_4
XFILLER_30_915 VPWR VGND sg13g2_decap_8
XFILLER_14_477 VPWR VGND sg13g2_decap_8
XFILLER_41_252 VPWR VGND sg13g2_decap_8
XFILLER_6_610 VPWR VGND sg13g2_decap_8
XFILLER_5_120 VPWR VGND sg13g2_decap_8
XFILLER_6_687 VPWR VGND sg13g2_decap_8
XFILLER_5_197 VPWR VGND sg13g2_decap_8
XFILLER_45_7 VPWR VGND sg13g2_decap_8
XFILLER_1_392 VPWR VGND sg13g2_decap_8
XFILLER_37_525 VPWR VGND sg13g2_decap_8
XFILLER_49_385 VPWR VGND sg13g2_decap_8
XFILLER_18_750 VPWR VGND sg13g2_fill_2
XFILLER_17_260 VPWR VGND sg13g2_decap_8
XFILLER_18_794 VPWR VGND sg13g2_fill_2
XFILLER_32_263 VPWR VGND sg13g2_decap_8
XFILLER_21_948 VPWR VGND sg13g2_decap_8
XFILLER_20_403 VPWR VGND sg13g2_decap_8
XFILLER_9_470 VPWR VGND sg13g2_decap_8
XFILLER_0_819 VPWR VGND sg13g2_decap_8
XFILLER_28_536 VPWR VGND sg13g2_decap_8
XFILLER_43_539 VPWR VGND sg13g2_decap_8
XFILLER_24_753 VPWR VGND sg13g2_decap_8
XFILLER_11_414 VPWR VGND sg13g2_decap_8
XFILLER_23_263 VPWR VGND sg13g2_decap_8
XFILLER_23_11 VPWR VGND sg13g2_decap_8
XdigitalL.g\[36\].u.inv VPWR digitalL.g\[36\].u.OUTN net92 VGND sg13g2_inv_1
XFILLER_7_407 VPWR VGND sg13g2_decap_8
XdigitalH.g\[78\].u.buff net60 digitalH.g\[78\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_23_88 VPWR VGND sg13g2_decap_8
XFILLER_3_624 VPWR VGND sg13g2_decap_8
XFILLER_2_134 VPWR VGND sg13g2_decap_8
XFILLER_48_63 VPWR VGND sg13g2_decap_8
XFILLER_47_812 VPWR VGND sg13g2_decap_8
XFILLER_46_322 VPWR VGND sg13g2_decap_8
XFILLER_47_889 VPWR VGND sg13g2_decap_8
XFILLER_19_569 VPWR VGND sg13g2_decap_8
XFILLER_46_399 VPWR VGND sg13g2_decap_8
XFILLER_34_539 VPWR VGND sg13g2_decap_8
XFILLER_14_274 VPWR VGND sg13g2_decap_8
XFILLER_9_57 VPWR VGND sg13g2_decap_8
XFILLER_30_767 VPWR VGND sg13g2_decap_8
XFILLER_7_985 VPWR VGND sg13g2_fill_1
XFILLER_6_484 VPWR VGND sg13g2_decap_8
XFILLER_49_182 VPWR VGND sg13g2_decap_8
XFILLER_37_322 VPWR VGND sg13g2_decap_8
XFILLER_37_399 VPWR VGND sg13g2_decap_8
XFILLER_20_200 VPWR VGND sg13g2_decap_8
XFILLER_21_778 VPWR VGND sg13g2_decap_8
XFILLER_20_277 VPWR VGND sg13g2_decap_8
XFILLER_0_616 VPWR VGND sg13g2_decap_8
XFILLER_48_609 VPWR VGND sg13g2_decap_8
XFILLER_47_119 VPWR VGND sg13g2_decap_8
XFILLER_29_823 VPWR VGND sg13g2_decap_8
XFILLER_18_22 VPWR VGND sg13g2_decap_8
XFILLER_28_333 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[1\].u.inv VPWR digitalenL.g\[1\].u.OUTN net3 VGND sg13g2_inv_1
XFILLER_18_99 VPWR VGND sg13g2_decap_8
XdigitalL.g\[31\].u.buff net84 digitalL.g\[31\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_336 VPWR VGND sg13g2_decap_8
XFILLER_34_21 VPWR VGND sg13g2_decap_8
XFILLER_24_550 VPWR VGND sg13g2_decap_8
XFILLER_11_211 VPWR VGND sg13g2_decap_8
XFILLER_34_98 VPWR VGND sg13g2_decap_8
XFILLER_7_204 VPWR VGND sg13g2_decap_8
XFILLER_11_288 VPWR VGND sg13g2_decap_8
XFILLER_4_911 VPWR VGND sg13g2_decap_8
XdigitalH.g\[82\].u.inv VPWR digitalH.g\[82\].u.OUTN net58 VGND sg13g2_inv_1
XdigitalH.g\[125\].u.buff net22 digitalH.g\[125\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_421 VPWR VGND sg13g2_decap_8
XFILLER_4_988 VPWR VGND sg13g2_decap_8
XFILLER_1_0 VPWR VGND sg13g2_decap_8
XFILLER_3_498 VPWR VGND sg13g2_decap_8
XFILLER_39_609 VPWR VGND sg13g2_decap_8
XFILLER_38_119 VPWR VGND sg13g2_decap_8
XFILLER_15_8 VPWR VGND sg13g2_decap_8
XFILLER_19_366 VPWR VGND sg13g2_decap_8
XFILLER_47_686 VPWR VGND sg13g2_decap_8
XFILLER_46_196 VPWR VGND sg13g2_decap_8
XFILLER_34_336 VPWR VGND sg13g2_decap_8
XFILLER_15_561 VPWR VGND sg13g2_decap_8
XFILLER_30_564 VPWR VGND sg13g2_decap_8
XFILLER_7_771 VPWR VGND sg13g2_decap_4
XFILLER_6_281 VPWR VGND sg13g2_decap_8
XFILLER_34_0 VPWR VGND sg13g2_decap_8
XFILLER_38_686 VPWR VGND sg13g2_decap_8
XFILLER_26_837 VPWR VGND sg13g2_decap_8
XFILLER_1_91 VPWR VGND sg13g2_decap_8
XFILLER_37_196 VPWR VGND sg13g2_decap_8
XFILLER_25_347 VPWR VGND sg13g2_decap_8
XFILLER_21_564 VPWR VGND sg13g2_decap_8
XFILLER_5_708 VPWR VGND sg13g2_decap_8
XFILLER_4_218 VPWR VGND sg13g2_decap_8
XFILLER_20_67 VPWR VGND sg13g2_decap_8
XFILLER_1_903 VPWR VGND sg13g2_decap_8
XFILLER_0_413 VPWR VGND sg13g2_decap_8
XFILLER_48_406 VPWR VGND sg13g2_decap_8
XFILLER_29_32 VPWR VGND sg13g2_decap_8
XFILLER_29_620 VPWR VGND sg13g2_decap_8
XdigitalH.g\[29\].u.inv VPWR digitalH.g\[29\].u.OUTN net30 VGND sg13g2_inv_1
XFILLER_28_130 VPWR VGND sg13g2_decap_8
XdigitalL.g\[115\].u.buff net78 digitalL.g\[115\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_44_623 VPWR VGND sg13g2_decap_8
XFILLER_29_697 VPWR VGND sg13g2_decap_8
XFILLER_16_358 VPWR VGND sg13g2_decap_8
XFILLER_45_42 VPWR VGND sg13g2_decap_8
XFILLER_43_133 VPWR VGND sg13g2_decap_8
XFILLER_32_807 VPWR VGND sg13g2_fill_1
XdigitalH.g\[93\].u.buff net55 digitalH.g\[93\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_12_564 VPWR VGND sg13g2_decap_8
XdigitalH.g\[22\].u.buff net29 digitalH.g\[22\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_8_568 VPWR VGND sg13g2_decap_8
XFILLER_6_36 VPWR VGND sg13g2_decap_8
XFILLER_4_785 VPWR VGND sg13g2_decap_8
XFILLER_3_295 VPWR VGND sg13g2_decap_8
XFILLER_6_1007 VPWR VGND sg13g2_decap_8
XFILLER_39_406 VPWR VGND sg13g2_decap_8
XFILLER_0_980 VPWR VGND sg13g2_decap_8
XFILLER_48_973 VPWR VGND sg13g2_decap_8
XFILLER_47_483 VPWR VGND sg13g2_decap_8
XFILLER_35_623 VPWR VGND sg13g2_decap_8
XFILLER_19_163 VPWR VGND sg13g2_decap_8
XFILLER_34_133 VPWR VGND sg13g2_decap_8
XFILLER_30_361 VPWR VGND sg13g2_decap_8
XdigitalH.g\[30\].u.inv VPWR digitalH.g\[30\].u.OUTN net30 VGND sg13g2_inv_1
XdigitalL.g\[6\].u.buff net71 digitalL.g\[6\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_483 VPWR VGND sg13g2_decap_8
XFILLER_26_634 VPWR VGND sg13g2_decap_8
XFILLER_25_144 VPWR VGND sg13g2_decap_8
XFILLER_41_637 VPWR VGND sg13g2_decap_8
XFILLER_15_78 VPWR VGND sg13g2_decap_8
XFILLER_40_147 VPWR VGND sg13g2_decap_8
XFILLER_22_851 VPWR VGND sg13g2_decap_8
XFILLER_21_361 VPWR VGND sg13g2_decap_8
XFILLER_5_505 VPWR VGND sg13g2_decap_8
XFILLER_31_11 VPWR VGND sg13g2_decap_8
XFILLER_31_88 VPWR VGND sg13g2_decap_8
Xoutput11 net11 uio_out[6] VPWR VGND sg13g2_buf_1
Xoutput9 net9 uio_out[4] VPWR VGND sg13g2_buf_1
XFILLER_1_700 VPWR VGND sg13g2_decap_8
XFILLER_0_210 VPWR VGND sg13g2_decap_8
XFILLER_1_777 VPWR VGND sg13g2_decap_8
XFILLER_0_287 VPWR VGND sg13g2_decap_8
XFILLER_48_203 VPWR VGND sg13g2_decap_8
XFILLER_45_910 VPWR VGND sg13g2_decap_8
XFILLER_17_645 VPWR VGND sg13g2_decap_8
XFILLER_44_420 VPWR VGND sg13g2_decap_8
XFILLER_29_494 VPWR VGND sg13g2_decap_8
XFILLER_16_155 VPWR VGND sg13g2_decap_8
XFILLER_45_987 VPWR VGND sg13g2_decap_8
XFILLER_44_497 VPWR VGND sg13g2_decap_8
XFILLER_32_648 VPWR VGND sg13g2_decap_8
XFILLER_31_158 VPWR VGND sg13g2_decap_8
XFILLER_12_361 VPWR VGND sg13g2_decap_8
XdigitalL.g\[84\].u.inv VPWR digitalL.g\[84\].u.OUTN net99 VGND sg13g2_inv_1
XFILLER_8_365 VPWR VGND sg13g2_decap_8
XFILLER_4_582 VPWR VGND sg13g2_decap_8
XFILLER_28_1019 VPWR VGND sg13g2_decap_8
XFILLER_39_203 VPWR VGND sg13g2_decap_8
XFILLER_48_770 VPWR VGND sg13g2_decap_8
XFILLER_47_280 VPWR VGND sg13g2_decap_8
XFILLER_35_420 VPWR VGND sg13g2_decap_8
XFILLER_35_497 VPWR VGND sg13g2_decap_8
XFILLER_23_648 VPWR VGND sg13g2_decap_8
XFILLER_22_158 VPWR VGND sg13g2_decap_8
XFILLER_2_519 VPWR VGND sg13g2_decap_8
XFILLER_46_707 VPWR VGND sg13g2_decap_8
XFILLER_45_217 VPWR VGND sg13g2_decap_8
XFILLER_27_910 VPWR VGND sg13g2_decap_8
XFILLER_38_280 VPWR VGND sg13g2_decap_8
XFILLER_26_431 VPWR VGND sg13g2_decap_8
XFILLER_26_11 VPWR VGND sg13g2_decap_8
XFILLER_27_987 VPWR VGND sg13g2_decap_8
XFILLER_26_88 VPWR VGND sg13g2_decap_8
XFILLER_14_659 VPWR VGND sg13g2_decap_8
XFILLER_41_434 VPWR VGND sg13g2_decap_8
XFILLER_13_169 VPWR VGND sg13g2_decap_8
XFILLER_42_21 VPWR VGND sg13g2_decap_8
XFILLER_5_302 VPWR VGND sg13g2_decap_8
XFILLER_6_814 VPWR VGND sg13g2_fill_1
XFILLER_6_836 VPWR VGND sg13g2_decap_4
XFILLER_42_98 VPWR VGND sg13g2_decap_8
XFILLER_6_869 VPWR VGND sg13g2_decap_8
XFILLER_5_379 VPWR VGND sg13g2_decap_8
XFILLER_3_15 VPWR VGND sg13g2_decap_8
XFILLER_1_574 VPWR VGND sg13g2_decap_8
XFILLER_49_567 VPWR VGND sg13g2_decap_8
XFILLER_37_707 VPWR VGND sg13g2_decap_8
XFILLER_36_217 VPWR VGND sg13g2_decap_8
XFILLER_29_291 VPWR VGND sg13g2_decap_8
XFILLER_18_932 VPWR VGND sg13g2_fill_1
XFILLER_17_442 VPWR VGND sg13g2_decap_8
XFILLER_45_784 VPWR VGND sg13g2_decap_8
XFILLER_44_294 VPWR VGND sg13g2_decap_8
XFILLER_32_445 VPWR VGND sg13g2_decap_8
XFILLER_9_652 VPWR VGND sg13g2_decap_8
XFILLER_8_162 VPWR VGND sg13g2_decap_8
Xfanout108 net112 net108 VPWR VGND sg13g2_buf_1
XFILLER_28_718 VPWR VGND sg13g2_decap_8
XFILLER_27_217 VPWR VGND sg13g2_decap_8
XFILLER_24_935 VPWR VGND sg13g2_decap_8
XFILLER_35_294 VPWR VGND sg13g2_decap_8
XFILLER_23_445 VPWR VGND sg13g2_decap_8
XFILLER_10_117 VPWR VGND sg13g2_decap_8
XFILLER_12_46 VPWR VGND sg13g2_decap_8
XdigitalL.g\[56\].u.buff net103 digitalL.g\[56\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_806 VPWR VGND sg13g2_decap_8
XFILLER_2_316 VPWR VGND sg13g2_decap_8
XdigitalL.g\[32\].u.inv VPWR digitalL.g\[32\].u.OUTN net84 VGND sg13g2_inv_1
XFILLER_46_504 VPWR VGND sg13g2_decap_8
XFILLER_37_21 VPWR VGND sg13g2_decap_8
XFILLER_18_239 VPWR VGND sg13g2_decap_8
XFILLER_37_98 VPWR VGND sg13g2_decap_8
XFILLER_42_721 VPWR VGND sg13g2_decap_8
XFILLER_27_784 VPWR VGND sg13g2_decap_8
XFILLER_14_456 VPWR VGND sg13g2_decap_8
XFILLER_18_1007 VPWR VGND sg13g2_fill_1
XFILLER_41_231 VPWR VGND sg13g2_decap_8
XFILLER_10_684 VPWR VGND sg13g2_decap_8
XFILLER_6_666 VPWR VGND sg13g2_decap_8
XFILLER_5_176 VPWR VGND sg13g2_decap_8
XdigitalL.g\[127\].u.inv VPWR digitalL.g\[127\].u.OUTN net114 VGND sg13g2_inv_1
XFILLER_38_7 VPWR VGND sg13g2_decap_8
XFILLER_2_883 VPWR VGND sg13g2_decap_8
XFILLER_1_371 VPWR VGND sg13g2_decap_8
XFILLER_49_364 VPWR VGND sg13g2_decap_8
XFILLER_37_504 VPWR VGND sg13g2_decap_8
XdigitalH.g\[77\].u.inv VPWR digitalH.g\[77\].u.OUTN net60 VGND sg13g2_inv_1
XFILLER_45_581 VPWR VGND sg13g2_decap_8
XFILLER_33_721 VPWR VGND sg13g2_decap_8
XFILLER_18_784 VPWR VGND sg13g2_fill_2
XFILLER_32_242 VPWR VGND sg13g2_decap_8
XFILLER_21_927 VPWR VGND sg13g2_decap_8
XFILLER_20_459 VPWR VGND sg13g2_decap_8
XFILLER_28_515 VPWR VGND sg13g2_decap_8
XFILLER_43_518 VPWR VGND sg13g2_decap_8
XFILLER_36_581 VPWR VGND sg13g2_decap_8
XFILLER_24_732 VPWR VGND sg13g2_decap_8
XFILLER_23_242 VPWR VGND sg13g2_decap_8
XFILLER_23_67 VPWR VGND sg13g2_decap_8
XFILLER_20_971 VPWR VGND sg13g2_decap_4
XFILLER_3_603 VPWR VGND sg13g2_decap_8
XFILLER_2_113 VPWR VGND sg13g2_decap_8
XdigitalH.g\[47\].u.buff net48 digitalH.g\[47\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_42 VPWR VGND sg13g2_decap_8
XFILLER_46_301 VPWR VGND sg13g2_decap_8
XFILLER_19_548 VPWR VGND sg13g2_decap_8
XFILLER_0_49 VPWR VGND sg13g2_decap_8
XFILLER_47_868 VPWR VGND sg13g2_decap_8
XFILLER_46_378 VPWR VGND sg13g2_decap_8
XFILLER_34_518 VPWR VGND sg13g2_decap_8
XFILLER_27_581 VPWR VGND sg13g2_decap_8
XFILLER_15_732 VPWR VGND sg13g2_fill_1
XFILLER_14_253 VPWR VGND sg13g2_decap_8
XFILLER_9_36 VPWR VGND sg13g2_decap_8
XFILLER_42_595 VPWR VGND sg13g2_decap_8
XFILLER_30_746 VPWR VGND sg13g2_decap_8
Xfanout90 net91 net90 VPWR VGND sg13g2_buf_1
XFILLER_10_481 VPWR VGND sg13g2_decap_8
XFILLER_6_463 VPWR VGND sg13g2_decap_8
XFILLER_2_680 VPWR VGND sg13g2_decap_8
XFILLER_49_161 VPWR VGND sg13g2_decap_8
XFILLER_37_301 VPWR VGND sg13g2_decap_8
XFILLER_37_378 VPWR VGND sg13g2_decap_8
XFILLER_25_529 VPWR VGND sg13g2_decap_8
XFILLER_33_595 VPWR VGND sg13g2_decap_8
XFILLER_21_746 VPWR VGND sg13g2_decap_8
XFILLER_20_256 VPWR VGND sg13g2_decap_8
XFILLER_47_1022 VPWR VGND sg13g2_decap_8
XFILLER_29_802 VPWR VGND sg13g2_decap_8
XFILLER_28_312 VPWR VGND sg13g2_decap_8
XFILLER_44_805 VPWR VGND sg13g2_decap_8
XFILLER_29_879 VPWR VGND sg13g2_decap_8
XFILLER_43_315 VPWR VGND sg13g2_decap_8
XFILLER_28_389 VPWR VGND sg13g2_decap_8
XFILLER_18_78 VPWR VGND sg13g2_decap_8
XFILLER_34_77 VPWR VGND sg13g2_decap_8
XdigitalL.g\[71\].u.buff net109 digitalL.g\[71\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_11_267 VPWR VGND sg13g2_decap_8
XdigitalH.g\[25\].u.inv VPWR digitalH.g\[25\].u.OUTN net29 VGND sg13g2_inv_1
XFILLER_3_400 VPWR VGND sg13g2_decap_8
XFILLER_4_967 VPWR VGND sg13g2_decap_8
XFILLER_3_477 VPWR VGND sg13g2_decap_8
XFILLER_47_665 VPWR VGND sg13g2_decap_8
XFILLER_19_345 VPWR VGND sg13g2_decap_8
XFILLER_46_175 VPWR VGND sg13g2_decap_8
XFILLER_34_315 VPWR VGND sg13g2_decap_8
XFILLER_15_540 VPWR VGND sg13g2_decap_8
XFILLER_42_392 VPWR VGND sg13g2_decap_8
XFILLER_30_543 VPWR VGND sg13g2_decap_8
XFILLER_7_750 VPWR VGND sg13g2_decap_8
XFILLER_6_260 VPWR VGND sg13g2_decap_8
XFILLER_7_794 VPWR VGND sg13g2_decap_4
XFILLER_29_109 VPWR VGND sg13g2_decap_8
XFILLER_27_0 VPWR VGND sg13g2_decap_8
XdigitalL.g\[79\].u.inv VPWR digitalL.g\[79\].u.OUTN net100 VGND sg13g2_inv_1
XFILLER_38_665 VPWR VGND sg13g2_decap_8
XFILLER_37_175 VPWR VGND sg13g2_decap_8
XFILLER_26_816 VPWR VGND sg13g2_decap_8
XFILLER_1_70 VPWR VGND sg13g2_decap_8
XFILLER_25_326 VPWR VGND sg13g2_decap_8
XFILLER_40_329 VPWR VGND sg13g2_decap_8
XFILLER_33_392 VPWR VGND sg13g2_decap_8
XFILLER_21_543 VPWR VGND sg13g2_decap_8
XFILLER_20_46 VPWR VGND sg13g2_decap_8
XFILLER_29_11 VPWR VGND sg13g2_decap_8
XFILLER_1_959 VPWR VGND sg13g2_decap_8
XFILLER_0_469 VPWR VGND sg13g2_decap_8
XFILLER_29_88 VPWR VGND sg13g2_decap_8
XFILLER_21_1025 VPWR VGND sg13g2_decap_4
XFILLER_45_21 VPWR VGND sg13g2_decap_8
XFILLER_44_602 VPWR VGND sg13g2_decap_8
XFILLER_29_676 VPWR VGND sg13g2_decap_8
XFILLER_16_337 VPWR VGND sg13g2_decap_8
XFILLER_43_112 VPWR VGND sg13g2_decap_8
XFILLER_28_186 VPWR VGND sg13g2_decap_8
XFILLER_45_98 VPWR VGND sg13g2_decap_8
XFILLER_44_679 VPWR VGND sg13g2_decap_8
XFILLER_43_189 VPWR VGND sg13g2_decap_8
XFILLER_25_893 VPWR VGND sg13g2_decap_8
XFILLER_12_543 VPWR VGND sg13g2_decap_8
XFILLER_6_15 VPWR VGND sg13g2_decap_8
XFILLER_8_547 VPWR VGND sg13g2_decap_8
XdigitalH.g\[62\].u.buff net53 digitalH.g\[62\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[8\].u.inv VPWR digitalH.g\[8\].u.OUTN net25 VGND sg13g2_inv_1
XFILLER_4_764 VPWR VGND sg13g2_decap_8
XFILLER_3_274 VPWR VGND sg13g2_decap_8
XdigitalL.g\[80\].u.inv VPWR digitalL.g\[80\].u.OUTN net100 VGND sg13g2_inv_1
XFILLER_48_952 VPWR VGND sg13g2_decap_8
XFILLER_47_462 VPWR VGND sg13g2_decap_8
XFILLER_35_602 VPWR VGND sg13g2_decap_8
XFILLER_19_142 VPWR VGND sg13g2_decap_8
XFILLER_34_112 VPWR VGND sg13g2_decap_8
XFILLER_35_679 VPWR VGND sg13g2_decap_8
XFILLER_34_189 VPWR VGND sg13g2_decap_8
XFILLER_31_852 VPWR VGND sg13g2_fill_1
XFILLER_30_340 VPWR VGND sg13g2_decap_8
XFILLER_44_1025 VPWR VGND sg13g2_decap_4
XFILLER_38_462 VPWR VGND sg13g2_decap_8
XFILLER_26_613 VPWR VGND sg13g2_decap_8
XFILLER_25_123 VPWR VGND sg13g2_decap_8
XFILLER_41_616 VPWR VGND sg13g2_decap_8
XFILLER_15_57 VPWR VGND sg13g2_decap_8
XFILLER_40_126 VPWR VGND sg13g2_decap_8
XFILLER_22_830 VPWR VGND sg13g2_decap_8
XFILLER_21_340 VPWR VGND sg13g2_decap_8
XFILLER_31_67 VPWR VGND sg13g2_decap_8
Xoutput12 net12 uio_out[7] VPWR VGND sg13g2_buf_1
XFILLER_1_756 VPWR VGND sg13g2_decap_8
XFILLER_0_266 VPWR VGND sg13g2_decap_8
XFILLER_49_749 VPWR VGND sg13g2_decap_8
XFILLER_48_259 VPWR VGND sg13g2_decap_8
XFILLER_29_473 VPWR VGND sg13g2_decap_8
XFILLER_17_624 VPWR VGND sg13g2_decap_8
XFILLER_16_134 VPWR VGND sg13g2_decap_8
XFILLER_45_966 VPWR VGND sg13g2_decap_8
XFILLER_44_476 VPWR VGND sg13g2_decap_8
XFILLER_32_627 VPWR VGND sg13g2_decap_8
XFILLER_31_137 VPWR VGND sg13g2_decap_8
XFILLER_25_690 VPWR VGND sg13g2_decap_8
XFILLER_12_340 VPWR VGND sg13g2_decap_8
XdigitalL.g\[27\].u.inv VPWR digitalL.g\[27\].u.OUTN net83 VGND sg13g2_inv_1
XFILLER_8_344 VPWR VGND sg13g2_decap_8
XFILLER_40_693 VPWR VGND sg13g2_decap_8
XFILLER_4_561 VPWR VGND sg13g2_decap_8
XFILLER_39_259 VPWR VGND sg13g2_decap_8
XFILLER_35_476 VPWR VGND sg13g2_decap_8
XFILLER_23_627 VPWR VGND sg13g2_decap_8
XFILLER_22_137 VPWR VGND sg13g2_decap_8
XFILLER_26_410 VPWR VGND sg13g2_decap_8
XFILLER_27_966 VPWR VGND sg13g2_decap_8
XFILLER_14_638 VPWR VGND sg13g2_decap_8
XFILLER_41_413 VPWR VGND sg13g2_decap_8
XFILLER_26_67 VPWR VGND sg13g2_decap_8
XFILLER_26_487 VPWR VGND sg13g2_decap_8
XFILLER_13_148 VPWR VGND sg13g2_decap_8
XFILLER_42_77 VPWR VGND sg13g2_decap_8
XFILLER_6_826 VPWR VGND sg13g2_decap_4
XFILLER_5_358 VPWR VGND sg13g2_decap_8
XFILLER_1_553 VPWR VGND sg13g2_decap_8
XFILLER_49_546 VPWR VGND sg13g2_decap_8
XFILLER_18_911 VPWR VGND sg13g2_fill_2
XFILLER_17_421 VPWR VGND sg13g2_decap_8
XFILLER_29_270 VPWR VGND sg13g2_decap_8
XFILLER_45_763 VPWR VGND sg13g2_decap_8
XFILLER_17_498 VPWR VGND sg13g2_decap_8
XFILLER_44_273 VPWR VGND sg13g2_decap_8
XFILLER_32_424 VPWR VGND sg13g2_decap_8
XdigitalL.g\[123\].u.inv VPWR digitalL.g\[123\].u.OUTN net69 VGND sg13g2_inv_1
XFILLER_9_631 VPWR VGND sg13g2_decap_8
XFILLER_40_490 VPWR VGND sg13g2_decap_8
XFILLER_8_141 VPWR VGND sg13g2_decap_8
XdigitalH.g\[73\].u.inv VPWR digitalH.g\[73\].u.OUTN net61 VGND sg13g2_inv_1
Xfanout109 net111 net109 VPWR VGND sg13g2_buf_1
XFILLER_35_273 VPWR VGND sg13g2_decap_8
XFILLER_24_914 VPWR VGND sg13g2_decap_8
XFILLER_23_424 VPWR VGND sg13g2_decap_8
XFILLER_12_25 VPWR VGND sg13g2_decap_8
XFILLER_5_8 VPWR VGND sg13g2_decap_8
XdigitalL.g\[96\].u.buff net89 digitalL.g\[96\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[25\].u.buff net82 digitalL.g\[25\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_18_218 VPWR VGND sg13g2_decap_8
XFILLER_37_77 VPWR VGND sg13g2_decap_8
XFILLER_27_763 VPWR VGND sg13g2_decap_8
XFILLER_42_700 VPWR VGND sg13g2_decap_8
XFILLER_14_435 VPWR VGND sg13g2_decap_8
XdigitalH.g\[119\].u.buff net34 digitalH.g\[119\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_41_210 VPWR VGND sg13g2_decap_8
XFILLER_26_284 VPWR VGND sg13g2_decap_8
XFILLER_41_287 VPWR VGND sg13g2_decap_8
XFILLER_23_991 VPWR VGND sg13g2_decap_8
XFILLER_10_663 VPWR VGND sg13g2_decap_8
XFILLER_6_645 VPWR VGND sg13g2_decap_8
XFILLER_5_155 VPWR VGND sg13g2_decap_8
XFILLER_2_862 VPWR VGND sg13g2_decap_8
XFILLER_1_350 VPWR VGND sg13g2_decap_8
XFILLER_49_343 VPWR VGND sg13g2_decap_8
XFILLER_45_560 VPWR VGND sg13g2_decap_8
XFILLER_33_700 VPWR VGND sg13g2_decap_8
XFILLER_17_295 VPWR VGND sg13g2_decap_8
XFILLER_32_221 VPWR VGND sg13g2_decap_8
XFILLER_21_906 VPWR VGND sg13g2_decap_8
XFILLER_32_298 VPWR VGND sg13g2_decap_8
XFILLER_20_438 VPWR VGND sg13g2_decap_8
XFILLER_4_92 VPWR VGND sg13g2_decap_8
XFILLER_36_560 VPWR VGND sg13g2_decap_8
XFILLER_24_711 VPWR VGND sg13g2_decap_8
XFILLER_23_221 VPWR VGND sg13g2_decap_8
XFILLER_24_788 VPWR VGND sg13g2_decap_8
XFILLER_23_46 VPWR VGND sg13g2_decap_8
XFILLER_23_298 VPWR VGND sg13g2_decap_8
XFILLER_11_449 VPWR VGND sg13g2_decap_8
XdigitalL.g\[109\].u.buff net79 digitalL.g\[109\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_659 VPWR VGND sg13g2_decap_8
XFILLER_2_169 VPWR VGND sg13g2_decap_8
XFILLER_48_21 VPWR VGND sg13g2_decap_8
XFILLER_24_1012 VPWR VGND sg13g2_decap_8
XdigitalH.g\[87\].u.buff net55 digitalH.g\[87\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[16\].u.buff net27 digitalH.g\[16\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[21\].u.inv VPWR digitalH.g\[21\].u.OUTN net28 VGND sg13g2_inv_1
XFILLER_48_98 VPWR VGND sg13g2_decap_8
XFILLER_47_847 VPWR VGND sg13g2_decap_8
XFILLER_19_527 VPWR VGND sg13g2_decap_8
XFILLER_0_28 VPWR VGND sg13g2_decap_8
XFILLER_46_357 VPWR VGND sg13g2_decap_8
XFILLER_27_560 VPWR VGND sg13g2_decap_8
XFILLER_15_722 VPWR VGND sg13g2_decap_4
XFILLER_14_232 VPWR VGND sg13g2_decap_8
XFILLER_9_15 VPWR VGND sg13g2_decap_8
XFILLER_42_574 VPWR VGND sg13g2_decap_8
XFILLER_30_725 VPWR VGND sg13g2_decap_8
Xfanout80 net91 net80 VPWR VGND sg13g2_buf_1
Xfanout91 net114 net91 VPWR VGND sg13g2_buf_1
XFILLER_10_460 VPWR VGND sg13g2_decap_8
XFILLER_31_1027 VPWR VGND sg13g2_fill_2
XFILLER_6_442 VPWR VGND sg13g2_decap_8
XFILLER_49_140 VPWR VGND sg13g2_decap_8
XFILLER_29_4 VPWR VGND sg13g2_decap_8
XFILLER_37_357 VPWR VGND sg13g2_decap_8
XFILLER_25_508 VPWR VGND sg13g2_decap_8
XFILLER_18_582 VPWR VGND sg13g2_decap_8
XFILLER_33_574 VPWR VGND sg13g2_decap_8
XFILLER_21_725 VPWR VGND sg13g2_decap_8
XdigitalL.g\[75\].u.inv VPWR digitalL.g\[75\].u.OUTN net107 VGND sg13g2_inv_1
XFILLER_20_235 VPWR VGND sg13g2_decap_8
XFILLER_47_1001 VPWR VGND sg13g2_decap_8
XFILLER_29_858 VPWR VGND sg13g2_decap_8
XFILLER_18_57 VPWR VGND sg13g2_decap_8
XFILLER_16_519 VPWR VGND sg13g2_decap_8
XFILLER_28_368 VPWR VGND sg13g2_decap_8
XFILLER_12_725 VPWR VGND sg13g2_decap_8
XFILLER_34_56 VPWR VGND sg13g2_decap_8
XFILLER_24_585 VPWR VGND sg13g2_decap_8
XFILLER_11_246 VPWR VGND sg13g2_decap_8
XFILLER_8_729 VPWR VGND sg13g2_decap_8
XFILLER_7_239 VPWR VGND sg13g2_decap_8
XFILLER_20_791 VPWR VGND sg13g2_decap_8
XFILLER_4_946 VPWR VGND sg13g2_decap_8
XdigitalL.g\[40\].u.buff net93 digitalL.g\[40\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_456 VPWR VGND sg13g2_decap_8
XFILLER_47_644 VPWR VGND sg13g2_decap_8
XFILLER_19_324 VPWR VGND sg13g2_decap_8
XFILLER_46_154 VPWR VGND sg13g2_decap_8
XdigitalH.g\[4\].u.inv VPWR digitalH.g\[4\].u.OUTN net38 VGND sg13g2_inv_1
XFILLER_15_596 VPWR VGND sg13g2_decap_8
XFILLER_42_371 VPWR VGND sg13g2_decap_8
XFILLER_30_522 VPWR VGND sg13g2_decap_8
XFILLER_30_599 VPWR VGND sg13g2_decap_8
XFILLER_38_644 VPWR VGND sg13g2_decap_8
XFILLER_37_154 VPWR VGND sg13g2_decap_8
XFILLER_25_305 VPWR VGND sg13g2_decap_8
XFILLER_19_891 VPWR VGND sg13g2_decap_4
XFILLER_40_308 VPWR VGND sg13g2_decap_8
XFILLER_33_371 VPWR VGND sg13g2_decap_8
XFILLER_21_522 VPWR VGND sg13g2_decap_8
XFILLER_21_599 VPWR VGND sg13g2_decap_8
XFILLER_20_25 VPWR VGND sg13g2_decap_8
XFILLER_1_938 VPWR VGND sg13g2_decap_8
XFILLER_0_448 VPWR VGND sg13g2_decap_8
XFILLER_29_67 VPWR VGND sg13g2_decap_8
XFILLER_29_655 VPWR VGND sg13g2_decap_8
XFILLER_21_1004 VPWR VGND sg13g2_decap_8
XFILLER_28_165 VPWR VGND sg13g2_decap_8
XFILLER_16_316 VPWR VGND sg13g2_decap_8
XFILLER_44_658 VPWR VGND sg13g2_decap_8
XFILLER_45_77 VPWR VGND sg13g2_decap_8
XFILLER_43_168 VPWR VGND sg13g2_decap_8
XFILLER_31_319 VPWR VGND sg13g2_decap_8
XFILLER_25_872 VPWR VGND sg13g2_decap_8
XFILLER_12_522 VPWR VGND sg13g2_decap_8
XFILLER_24_382 VPWR VGND sg13g2_decap_8
XFILLER_8_526 VPWR VGND sg13g2_decap_8
XFILLER_12_599 VPWR VGND sg13g2_decap_8
XdigitalL.g\[124\].u.buff net69 digitalL.g\[124\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_743 VPWR VGND sg13g2_decap_8
XFILLER_3_253 VPWR VGND sg13g2_decap_8
XdigitalH.g\[31\].u.buff net30 digitalH.g\[31\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[23\].u.inv VPWR digitalL.g\[23\].u.OUTN net82 VGND sg13g2_inv_1
XFILLER_48_931 VPWR VGND sg13g2_decap_8
XFILLER_47_441 VPWR VGND sg13g2_decap_8
XFILLER_19_121 VPWR VGND sg13g2_decap_8
XFILLER_19_198 VPWR VGND sg13g2_decap_8
XFILLER_35_658 VPWR VGND sg13g2_decap_8
XFILLER_23_809 VPWR VGND sg13g2_decap_8
XFILLER_34_168 VPWR VGND sg13g2_decap_8
XFILLER_22_319 VPWR VGND sg13g2_decap_8
XFILLER_15_393 VPWR VGND sg13g2_decap_8
XFILLER_30_396 VPWR VGND sg13g2_decap_8
XFILLER_44_1004 VPWR VGND sg13g2_decap_8
XdigitalL.g\[118\].u.inv VPWR digitalL.g\[118\].u.OUTN net76 VGND sg13g2_inv_1
XdigitalH.g\[68\].u.inv VPWR digitalH.g\[68\].u.OUTN net62 VGND sg13g2_inv_1
XFILLER_38_441 VPWR VGND sg13g2_decap_8
XFILLER_25_102 VPWR VGND sg13g2_decap_8
XFILLER_26_669 VPWR VGND sg13g2_decap_8
XFILLER_15_36 VPWR VGND sg13g2_decap_8
XFILLER_40_105 VPWR VGND sg13g2_decap_8
XFILLER_25_179 VPWR VGND sg13g2_decap_8
XFILLER_22_886 VPWR VGND sg13g2_decap_8
XFILLER_21_396 VPWR VGND sg13g2_decap_8
XFILLER_31_46 VPWR VGND sg13g2_decap_8
Xoutput13 net13 uo_out[0] VPWR VGND sg13g2_buf_1
XFILLER_1_735 VPWR VGND sg13g2_decap_8
XFILLER_0_245 VPWR VGND sg13g2_decap_8
XFILLER_49_728 VPWR VGND sg13g2_decap_8
XFILLER_48_238 VPWR VGND sg13g2_decap_8
XFILLER_17_603 VPWR VGND sg13g2_decap_8
XFILLER_29_452 VPWR VGND sg13g2_decap_8
XFILLER_16_113 VPWR VGND sg13g2_decap_8
XFILLER_45_945 VPWR VGND sg13g2_decap_8
XFILLER_44_455 VPWR VGND sg13g2_decap_8
XFILLER_32_606 VPWR VGND sg13g2_decap_8
XFILLER_31_116 VPWR VGND sg13g2_decap_8
XFILLER_40_672 VPWR VGND sg13g2_decap_8
XFILLER_12_396 VPWR VGND sg13g2_decap_8
XFILLER_8_323 VPWR VGND sg13g2_decap_8
XFILLER_4_540 VPWR VGND sg13g2_decap_8
XFILLER_39_238 VPWR VGND sg13g2_decap_8
XFILLER_35_455 VPWR VGND sg13g2_decap_8
XFILLER_23_606 VPWR VGND sg13g2_decap_8
XFILLER_22_116 VPWR VGND sg13g2_decap_8
XFILLER_16_680 VPWR VGND sg13g2_decap_8
XFILLER_15_190 VPWR VGND sg13g2_decap_8
XFILLER_31_683 VPWR VGND sg13g2_decap_8
XFILLER_30_193 VPWR VGND sg13g2_decap_8
XFILLER_7_92 VPWR VGND sg13g2_decap_8
XFILLER_27_945 VPWR VGND sg13g2_decap_8
XFILLER_26_46 VPWR VGND sg13g2_decap_8
XFILLER_14_617 VPWR VGND sg13g2_decap_8
XFILLER_42_937 VPWR VGND sg13g2_fill_1
XFILLER_26_466 VPWR VGND sg13g2_decap_8
XFILLER_13_127 VPWR VGND sg13g2_decap_8
XFILLER_41_469 VPWR VGND sg13g2_decap_8
XFILLER_42_56 VPWR VGND sg13g2_decap_8
XFILLER_22_683 VPWR VGND sg13g2_decap_8
XFILLER_6_805 VPWR VGND sg13g2_fill_1
XFILLER_21_193 VPWR VGND sg13g2_decap_8
XFILLER_5_337 VPWR VGND sg13g2_decap_8
XFILLER_1_532 VPWR VGND sg13g2_decap_8
XFILLER_49_525 VPWR VGND sg13g2_decap_8
XFILLER_17_400 VPWR VGND sg13g2_decap_8
XFILLER_45_742 VPWR VGND sg13g2_decap_8
XFILLER_18_978 VPWR VGND sg13g2_fill_2
XFILLER_17_477 VPWR VGND sg13g2_decap_8
XFILLER_44_252 VPWR VGND sg13g2_decap_8
XFILLER_32_403 VPWR VGND sg13g2_decap_8
XFILLER_9_610 VPWR VGND sg13g2_decap_8
XFILLER_13_694 VPWR VGND sg13g2_decap_8
XFILLER_8_120 VPWR VGND sg13g2_decap_8
XFILLER_12_193 VPWR VGND sg13g2_decap_8
XFILLER_9_687 VPWR VGND sg13g2_decap_8
XdigitalH.g\[16\].u.inv VPWR digitalH.g\[16\].u.OUTN net26 VGND sg13g2_inv_1
XFILLER_8_197 VPWR VGND sg13g2_decap_8
XFILLER_35_252 VPWR VGND sg13g2_decap_8
XFILLER_23_403 VPWR VGND sg13g2_decap_8
XFILLER_31_480 VPWR VGND sg13g2_decap_8
XFILLER_19_709 VPWR VGND sg13g2_decap_8
XdigitalL.g\[65\].u.buff net109 digitalL.g\[65\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_539 VPWR VGND sg13g2_decap_8
XFILLER_37_56 VPWR VGND sg13g2_decap_8
XFILLER_2_1023 VPWR VGND sg13g2_decap_4
XFILLER_27_742 VPWR VGND sg13g2_decap_8
XFILLER_14_414 VPWR VGND sg13g2_decap_8
XFILLER_26_263 VPWR VGND sg13g2_decap_8
XFILLER_42_789 VPWR VGND sg13g2_fill_2
XFILLER_41_266 VPWR VGND sg13g2_decap_8
XFILLER_30_929 VPWR VGND sg13g2_decap_8
XFILLER_23_970 VPWR VGND sg13g2_decap_8
XFILLER_22_480 VPWR VGND sg13g2_decap_8
XFILLER_10_642 VPWR VGND sg13g2_decap_8
XFILLER_6_624 VPWR VGND sg13g2_decap_8
XFILLER_5_134 VPWR VGND sg13g2_decap_8
XFILLER_2_841 VPWR VGND sg13g2_decap_8
XFILLER_49_322 VPWR VGND sg13g2_decap_8
XFILLER_49_399 VPWR VGND sg13g2_decap_8
XFILLER_37_539 VPWR VGND sg13g2_decap_8
XFILLER_18_786 VPWR VGND sg13g2_fill_1
XFILLER_17_274 VPWR VGND sg13g2_decap_8
XFILLER_32_200 VPWR VGND sg13g2_decap_8
XFILLER_32_277 VPWR VGND sg13g2_decap_8
XFILLER_20_417 VPWR VGND sg13g2_decap_8
XFILLER_13_491 VPWR VGND sg13g2_decap_8
XFILLER_9_484 VPWR VGND sg13g2_decap_8
XFILLER_4_71 VPWR VGND sg13g2_decap_8
XdigitalL.g\[71\].u.inv VPWR digitalL.g\[71\].u.OUTN net112 VGND sg13g2_inv_1
XFILLER_23_200 VPWR VGND sg13g2_decap_8
XFILLER_24_767 VPWR VGND sg13g2_decap_8
XFILLER_11_428 VPWR VGND sg13g2_decap_8
XFILLER_23_277 VPWR VGND sg13g2_decap_8
XFILLER_23_25 VPWR VGND sg13g2_decap_8
XFILLER_20_951 VPWR VGND sg13g2_decap_4
XFILLER_20_984 VPWR VGND sg13g2_fill_1
XFILLER_3_638 VPWR VGND sg13g2_decap_8
XFILLER_2_148 VPWR VGND sg13g2_decap_8
XFILLER_19_506 VPWR VGND sg13g2_decap_8
XFILLER_48_77 VPWR VGND sg13g2_decap_8
XFILLER_47_826 VPWR VGND sg13g2_decap_8
XFILLER_46_336 VPWR VGND sg13g2_decap_8
XFILLER_15_701 VPWR VGND sg13g2_decap_8
XFILLER_14_211 VPWR VGND sg13g2_decap_8
XdigitalH.g\[56\].u.buff net51 digitalH.g\[56\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_42_553 VPWR VGND sg13g2_decap_8
XFILLER_30_704 VPWR VGND sg13g2_decap_8
XFILLER_14_288 VPWR VGND sg13g2_decap_8
Xfanout70 net114 net70 VPWR VGND sg13g2_buf_1
Xfanout81 net85 net81 VPWR VGND sg13g2_buf_1
Xfanout92 net96 net92 VPWR VGND sg13g2_buf_1
XFILLER_6_421 VPWR VGND sg13g2_decap_8
XdigitalH.g\[0\].u.inv VPWR digitalH.g\[0\].u.OUTN net21 VGND sg13g2_inv_1
XFILLER_6_498 VPWR VGND sg13g2_decap_8
XFILLER_43_7 VPWR VGND sg13g2_decap_8
XFILLER_49_196 VPWR VGND sg13g2_decap_8
XFILLER_37_336 VPWR VGND sg13g2_decap_8
XFILLER_18_561 VPWR VGND sg13g2_decap_8
XFILLER_33_553 VPWR VGND sg13g2_decap_8
XFILLER_21_704 VPWR VGND sg13g2_decap_8
XFILLER_20_214 VPWR VGND sg13g2_decap_8
XdigitalH.g\[127\].u.inv VPWR digitalH.g\[127\].u.OUTN net22 VGND sg13g2_inv_1
XdigitalL.g\[18\].u.inv VPWR digitalL.g\[18\].u.OUTN net81 VGND sg13g2_inv_1
XFILLER_9_281 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[3\].u.buff net4 digitalenH.g\[3\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_837 VPWR VGND sg13g2_decap_8
XFILLER_28_347 VPWR VGND sg13g2_decap_8
XFILLER_18_36 VPWR VGND sg13g2_decap_8
XFILLER_44_829 VPWR VGND sg13g2_decap_8
XFILLER_12_704 VPWR VGND sg13g2_decap_8
XFILLER_34_35 VPWR VGND sg13g2_decap_8
XFILLER_24_564 VPWR VGND sg13g2_decap_8
XFILLER_11_225 VPWR VGND sg13g2_decap_8
XFILLER_8_708 VPWR VGND sg13g2_decap_8
XFILLER_7_218 VPWR VGND sg13g2_decap_8
XFILLER_20_770 VPWR VGND sg13g2_decap_8
XFILLER_4_925 VPWR VGND sg13g2_decap_8
XFILLER_3_435 VPWR VGND sg13g2_decap_8
XdigitalL.g\[80\].u.buff net100 digitalL.g\[80\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_623 VPWR VGND sg13g2_decap_8
XFILLER_19_303 VPWR VGND sg13g2_decap_8
XFILLER_46_133 VPWR VGND sg13g2_decap_8
XdigitalH.g\[4\].u.buff net24 digitalH.g\[4\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_15_575 VPWR VGND sg13g2_decap_8
XdigitalH.g\[103\].u.buff net40 digitalH.g\[103\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_42_350 VPWR VGND sg13g2_decap_8
XFILLER_30_501 VPWR VGND sg13g2_decap_8
XFILLER_30_578 VPWR VGND sg13g2_decap_8
XFILLER_7_785 VPWR VGND sg13g2_decap_4
XFILLER_6_295 VPWR VGND sg13g2_decap_8
XFILLER_38_623 VPWR VGND sg13g2_decap_8
XFILLER_37_133 VPWR VGND sg13g2_decap_8
XFILLER_19_870 VPWR VGND sg13g2_decap_4
XFILLER_33_350 VPWR VGND sg13g2_decap_8
XFILLER_21_501 VPWR VGND sg13g2_decap_8
XdigitalL.g\[114\].u.inv VPWR digitalL.g\[114\].u.OUTN net78 VGND sg13g2_inv_1
XFILLER_21_578 VPWR VGND sg13g2_decap_8
XdigitalH.g\[64\].u.inv VPWR digitalH.g\[64\].u.OUTN net63 VGND sg13g2_inv_1
XFILLER_1_917 VPWR VGND sg13g2_decap_8
XFILLER_0_427 VPWR VGND sg13g2_decap_8
XFILLER_29_46 VPWR VGND sg13g2_decap_8
XFILLER_29_634 VPWR VGND sg13g2_decap_8
XFILLER_28_144 VPWR VGND sg13g2_decap_8
XFILLER_45_56 VPWR VGND sg13g2_decap_8
XFILLER_44_637 VPWR VGND sg13g2_decap_8
XFILLER_43_147 VPWR VGND sg13g2_decap_8
XFILLER_25_851 VPWR VGND sg13g2_decap_8
XFILLER_12_501 VPWR VGND sg13g2_decap_8
XFILLER_24_361 VPWR VGND sg13g2_decap_8
XFILLER_12_578 VPWR VGND sg13g2_decap_8
XFILLER_8_505 VPWR VGND sg13g2_decap_8
XFILLER_4_722 VPWR VGND sg13g2_decap_8
XFILLER_3_232 VPWR VGND sg13g2_decap_8
XFILLER_4_799 VPWR VGND sg13g2_decap_8
XFILLER_48_910 VPWR VGND sg13g2_decap_8
XFILLER_0_994 VPWR VGND sg13g2_decap_8
XFILLER_13_8 VPWR VGND sg13g2_decap_8
XdigitalH.g\[71\].u.buff net62 digitalH.g\[71\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_420 VPWR VGND sg13g2_decap_8
XFILLER_19_100 VPWR VGND sg13g2_decap_8
XFILLER_48_987 VPWR VGND sg13g2_decap_8
XFILLER_47_497 VPWR VGND sg13g2_decap_8
XFILLER_35_637 VPWR VGND sg13g2_decap_8
XFILLER_19_177 VPWR VGND sg13g2_decap_8
XFILLER_34_147 VPWR VGND sg13g2_decap_8
XFILLER_15_372 VPWR VGND sg13g2_decap_8
XFILLER_31_843 VPWR VGND sg13g2_fill_1
XFILLER_30_375 VPWR VGND sg13g2_decap_8
XFILLER_7_582 VPWR VGND sg13g2_decap_8
XFILLER_38_420 VPWR VGND sg13g2_decap_8
XFILLER_38_497 VPWR VGND sg13g2_decap_8
XFILLER_26_648 VPWR VGND sg13g2_decap_8
XFILLER_25_158 VPWR VGND sg13g2_decap_8
XFILLER_13_309 VPWR VGND sg13g2_decap_8
XFILLER_15_15 VPWR VGND sg13g2_decap_8
XFILLER_22_865 VPWR VGND sg13g2_decap_8
XFILLER_31_25 VPWR VGND sg13g2_decap_8
XFILLER_21_375 VPWR VGND sg13g2_decap_8
XFILLER_5_519 VPWR VGND sg13g2_decap_8
XdigitalL.g\[19\].u.buff net81 digitalL.g\[19\].u.OUTP VPWR VGND sg13g2_buf_1
Xoutput14 net14 uo_out[1] VPWR VGND sg13g2_buf_1
XFILLER_1_714 VPWR VGND sg13g2_decap_8
XFILLER_0_224 VPWR VGND sg13g2_decap_8
XFILLER_49_707 VPWR VGND sg13g2_decap_8
XFILLER_48_217 VPWR VGND sg13g2_decap_8
XFILLER_29_431 VPWR VGND sg13g2_decap_8
XFILLER_45_924 VPWR VGND sg13g2_decap_8
XFILLER_17_659 VPWR VGND sg13g2_decap_8
XFILLER_44_434 VPWR VGND sg13g2_decap_8
XFILLER_16_169 VPWR VGND sg13g2_decap_8
XFILLER_8_302 VPWR VGND sg13g2_decap_8
XFILLER_40_651 VPWR VGND sg13g2_decap_8
XFILLER_12_375 VPWR VGND sg13g2_decap_8
XFILLER_8_379 VPWR VGND sg13g2_decap_8
XFILLER_4_596 VPWR VGND sg13g2_decap_8
XFILLER_0_791 VPWR VGND sg13g2_decap_8
XFILLER_39_217 VPWR VGND sg13g2_decap_8
XdigitalH.g\[12\].u.inv VPWR digitalH.g\[12\].u.OUTN net26 VGND sg13g2_inv_1
XFILLER_48_784 VPWR VGND sg13g2_decap_8
XFILLER_47_294 VPWR VGND sg13g2_decap_8
XFILLER_35_434 VPWR VGND sg13g2_decap_8
XFILLER_44_990 VPWR VGND sg13g2_decap_8
XFILLER_31_662 VPWR VGND sg13g2_decap_8
XFILLER_30_172 VPWR VGND sg13g2_decap_8
XFILLER_7_71 VPWR VGND sg13g2_decap_8
XFILLER_27_924 VPWR VGND sg13g2_decap_8
XFILLER_38_294 VPWR VGND sg13g2_decap_8
XFILLER_26_445 VPWR VGND sg13g2_decap_8
XFILLER_26_25 VPWR VGND sg13g2_decap_8
XFILLER_13_106 VPWR VGND sg13g2_decap_8
XFILLER_41_448 VPWR VGND sg13g2_decap_8
XFILLER_42_35 VPWR VGND sg13g2_decap_8
XFILLER_22_662 VPWR VGND sg13g2_decap_8
XFILLER_21_172 VPWR VGND sg13g2_decap_8
XdigitalL.g\[66\].u.inv VPWR digitalL.g\[66\].u.OUTN net111 VGND sg13g2_inv_1
XFILLER_5_316 VPWR VGND sg13g2_decap_8
XFILLER_1_511 VPWR VGND sg13g2_decap_8
XFILLER_3_29 VPWR VGND sg13g2_decap_8
XFILLER_49_504 VPWR VGND sg13g2_decap_8
XFILLER_27_1022 VPWR VGND sg13g2_decap_8
XFILLER_1_588 VPWR VGND sg13g2_decap_8
XFILLER_45_721 VPWR VGND sg13g2_decap_8
XFILLER_44_231 VPWR VGND sg13g2_decap_8
XFILLER_18_968 VPWR VGND sg13g2_fill_2
XFILLER_18_957 VPWR VGND sg13g2_fill_1
XFILLER_17_456 VPWR VGND sg13g2_decap_8
XFILLER_45_798 VPWR VGND sg13g2_decap_8
XFILLER_32_459 VPWR VGND sg13g2_decap_8
XFILLER_12_172 VPWR VGND sg13g2_decap_8
XFILLER_13_673 VPWR VGND sg13g2_decap_8
XFILLER_9_666 VPWR VGND sg13g2_decap_8
XFILLER_8_176 VPWR VGND sg13g2_decap_8
XFILLER_5_883 VPWR VGND sg13g2_decap_8
XFILLER_4_393 VPWR VGND sg13g2_decap_8
XFILLER_48_581 VPWR VGND sg13g2_decap_8
XFILLER_36_721 VPWR VGND sg13g2_decap_8
XFILLER_35_231 VPWR VGND sg13g2_decap_8
XFILLER_24_949 VPWR VGND sg13g2_decap_8
XFILLER_23_459 VPWR VGND sg13g2_decap_8
XFILLER_46_518 VPWR VGND sg13g2_decap_8
XFILLER_39_581 VPWR VGND sg13g2_decap_8
XFILLER_37_35 VPWR VGND sg13g2_decap_8
XFILLER_2_1002 VPWR VGND sg13g2_decap_8
XFILLER_27_721 VPWR VGND sg13g2_decap_8
XFILLER_26_242 VPWR VGND sg13g2_decap_8
XFILLER_42_735 VPWR VGND sg13g2_decap_8
XFILLER_27_798 VPWR VGND sg13g2_decap_8
XdigitalL.g\[34\].u.buff net92 digitalL.g\[34\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_41_245 VPWR VGND sg13g2_decap_8
XFILLER_10_621 VPWR VGND sg13g2_decap_8
XFILLER_6_603 VPWR VGND sg13g2_decap_8
XFILLER_5_113 VPWR VGND sg13g2_decap_8
XFILLER_10_698 VPWR VGND sg13g2_decap_8
XFILLER_2_820 VPWR VGND sg13g2_decap_8
XFILLER_49_301 VPWR VGND sg13g2_decap_8
XFILLER_2_897 VPWR VGND sg13g2_decap_8
XFILLER_1_385 VPWR VGND sg13g2_decap_8
XdigitalL.g\[7\].u.inv VPWR digitalL.g\[7\].u.OUTN net72 VGND sg13g2_inv_1
XFILLER_49_378 VPWR VGND sg13g2_decap_8
XFILLER_37_518 VPWR VGND sg13g2_decap_8
XFILLER_18_743 VPWR VGND sg13g2_decap_8
XFILLER_17_253 VPWR VGND sg13g2_decap_8
XFILLER_18_776 VPWR VGND sg13g2_fill_2
XFILLER_45_595 VPWR VGND sg13g2_decap_8
XFILLER_32_256 VPWR VGND sg13g2_decap_8
XFILLER_13_470 VPWR VGND sg13g2_decap_8
XFILLER_9_463 VPWR VGND sg13g2_decap_8
XFILLER_5_680 VPWR VGND sg13g2_decap_8
XFILLER_4_190 VPWR VGND sg13g2_decap_8
XFILLER_4_50 VPWR VGND sg13g2_decap_8
XdigitalH.g\[123\].u.inv VPWR digitalH.g\[123\].u.OUTN net35 VGND sg13g2_inv_1
XdigitalL.g\[14\].u.inv VPWR digitalL.g\[14\].u.OUTN net73 VGND sg13g2_inv_1
XFILLER_28_529 VPWR VGND sg13g2_decap_8
XFILLER_36_595 VPWR VGND sg13g2_decap_8
XFILLER_24_746 VPWR VGND sg13g2_decap_8
XFILLER_23_256 VPWR VGND sg13g2_decap_8
XFILLER_11_407 VPWR VGND sg13g2_decap_8
XFILLER_20_996 VPWR VGND sg13g2_decap_8
XFILLER_3_617 VPWR VGND sg13g2_decap_8
XFILLER_2_127 VPWR VGND sg13g2_decap_8
XdigitalL.g\[109\].u.inv VPWR digitalL.g\[109\].u.OUTN net79 VGND sg13g2_inv_1
XFILLER_48_56 VPWR VGND sg13g2_decap_8
XFILLER_47_805 VPWR VGND sg13g2_decap_8
XFILLER_46_315 VPWR VGND sg13g2_decap_8
XdigitalH.g\[59\].u.inv VPWR digitalH.g\[59\].u.OUTN net52 VGND sg13g2_inv_1
XdigitalL.g\[118\].u.buff net76 digitalL.g\[118\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_27_595 VPWR VGND sg13g2_decap_8
XFILLER_42_532 VPWR VGND sg13g2_decap_8
XFILLER_14_267 VPWR VGND sg13g2_decap_8
XdigitalH.g\[96\].u.buff net42 digitalH.g\[96\].u.OUTP VPWR VGND sg13g2_buf_1
Xfanout60 net64 net60 VPWR VGND sg13g2_buf_1
Xfanout71 net75 net71 VPWR VGND sg13g2_buf_1
Xfanout82 net85 net82 VPWR VGND sg13g2_buf_1
XFILLER_6_400 VPWR VGND sg13g2_decap_8
XdigitalH.g\[25\].u.buff net29 digitalH.g\[25\].u.OUTP VPWR VGND sg13g2_buf_1
Xfanout93 net96 net93 VPWR VGND sg13g2_buf_1
XFILLER_10_495 VPWR VGND sg13g2_decap_8
XFILLER_13_92 VPWR VGND sg13g2_decap_8
XFILLER_6_477 VPWR VGND sg13g2_decap_8
XFILLER_36_7 VPWR VGND sg13g2_decap_8
XFILLER_2_694 VPWR VGND sg13g2_decap_8
XFILLER_1_182 VPWR VGND sg13g2_decap_8
XFILLER_49_175 VPWR VGND sg13g2_decap_8
XFILLER_37_315 VPWR VGND sg13g2_decap_8
XFILLER_18_540 VPWR VGND sg13g2_decap_8
XFILLER_46_882 VPWR VGND sg13g2_decap_8
XFILLER_45_392 VPWR VGND sg13g2_decap_8
XFILLER_33_532 VPWR VGND sg13g2_decap_8
XFILLER_9_260 VPWR VGND sg13g2_decap_8
XFILLER_0_609 VPWR VGND sg13g2_decap_8
XdigitalL.g\[110\].u.inv VPWR digitalL.g\[110\].u.OUTN net79 VGND sg13g2_inv_1
XFILLER_18_15 VPWR VGND sg13g2_decap_8
XFILLER_29_816 VPWR VGND sg13g2_decap_8
XdigitalH.g\[60\].u.inv VPWR digitalH.g\[60\].u.OUTN net65 VGND sg13g2_inv_1
XFILLER_28_326 VPWR VGND sg13g2_decap_8
XdigitalL.g\[9\].u.buff net72 digitalL.g\[9\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_329 VPWR VGND sg13g2_decap_8
XFILLER_36_392 VPWR VGND sg13g2_decap_8
XFILLER_34_14 VPWR VGND sg13g2_decap_8
XFILLER_24_543 VPWR VGND sg13g2_decap_8
XFILLER_11_204 VPWR VGND sg13g2_decap_8
XFILLER_20_760 VPWR VGND sg13g2_decap_4
XFILLER_4_904 VPWR VGND sg13g2_decap_8
XFILLER_3_414 VPWR VGND sg13g2_decap_8
XFILLER_47_602 VPWR VGND sg13g2_decap_8
XFILLER_46_112 VPWR VGND sg13g2_decap_8
XFILLER_47_679 VPWR VGND sg13g2_decap_8
XFILLER_19_359 VPWR VGND sg13g2_decap_8
XFILLER_46_189 VPWR VGND sg13g2_decap_8
XFILLER_34_329 VPWR VGND sg13g2_decap_8
XFILLER_28_893 VPWR VGND sg13g2_decap_8
XFILLER_15_554 VPWR VGND sg13g2_decap_8
XFILLER_27_392 VPWR VGND sg13g2_decap_8
XFILLER_30_557 VPWR VGND sg13g2_decap_8
XFILLER_10_292 VPWR VGND sg13g2_decap_8
XFILLER_7_775 VPWR VGND sg13g2_fill_2
XFILLER_6_274 VPWR VGND sg13g2_decap_8
XFILLER_3_981 VPWR VGND sg13g2_decap_8
XFILLER_2_491 VPWR VGND sg13g2_decap_8
XFILLER_38_602 VPWR VGND sg13g2_decap_8
XFILLER_37_112 VPWR VGND sg13g2_decap_8
XFILLER_38_679 VPWR VGND sg13g2_decap_8
XFILLER_37_189 VPWR VGND sg13g2_decap_8
XFILLER_1_84 VPWR VGND sg13g2_decap_8
XFILLER_21_557 VPWR VGND sg13g2_decap_8
XFILLER_0_406 VPWR VGND sg13g2_decap_8
XFILLER_29_25 VPWR VGND sg13g2_decap_8
XFILLER_29_613 VPWR VGND sg13g2_decap_8
XFILLER_28_123 VPWR VGND sg13g2_decap_8
XFILLER_45_35 VPWR VGND sg13g2_decap_8
XFILLER_44_616 VPWR VGND sg13g2_decap_8
XFILLER_43_126 VPWR VGND sg13g2_decap_8
XFILLER_25_830 VPWR VGND sg13g2_decap_8
XFILLER_24_340 VPWR VGND sg13g2_decap_8
XFILLER_12_557 VPWR VGND sg13g2_decap_8
XFILLER_4_701 VPWR VGND sg13g2_decap_8
XFILLER_6_29 VPWR VGND sg13g2_decap_8
XFILLER_3_211 VPWR VGND sg13g2_decap_8
XFILLER_10_82 VPWR VGND sg13g2_decap_8
XFILLER_4_778 VPWR VGND sg13g2_decap_8
XFILLER_3_288 VPWR VGND sg13g2_decap_8
XFILLER_0_973 VPWR VGND sg13g2_decap_8
XFILLER_48_966 VPWR VGND sg13g2_decap_8
XFILLER_19_156 VPWR VGND sg13g2_decap_8
XFILLER_47_476 VPWR VGND sg13g2_decap_8
XFILLER_35_616 VPWR VGND sg13g2_decap_8
XFILLER_34_126 VPWR VGND sg13g2_decap_8
XFILLER_28_690 VPWR VGND sg13g2_decap_8
XFILLER_15_351 VPWR VGND sg13g2_decap_8
XdigitalH.g\[40\].u.buff net45 digitalH.g\[40\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_693 VPWR VGND sg13g2_decap_8
XFILLER_31_833 VPWR VGND sg13g2_fill_2
XFILLER_30_354 VPWR VGND sg13g2_decap_8
XFILLER_7_561 VPWR VGND sg13g2_decap_8
XFILLER_38_476 VPWR VGND sg13g2_decap_8
XFILLER_26_627 VPWR VGND sg13g2_decap_8
X_09_ net115 net11 VPWR VGND sg13g2_buf_1
XFILLER_25_137 VPWR VGND sg13g2_decap_8
XFILLER_34_693 VPWR VGND sg13g2_decap_8
XFILLER_22_844 VPWR VGND sg13g2_decap_8
XFILLER_21_354 VPWR VGND sg13g2_decap_8
Xoutput15 net15 uo_out[2] VPWR VGND sg13g2_buf_1
XFILLER_0_203 VPWR VGND sg13g2_decap_8
XdigitalL.g\[59\].u.buff net104 digitalL.g\[59\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[62\].u.inv VPWR digitalL.g\[62\].u.OUTN net105 VGND sg13g2_inv_1
XFILLER_29_410 VPWR VGND sg13g2_decap_8
XFILLER_45_903 VPWR VGND sg13g2_decap_8
XFILLER_17_638 VPWR VGND sg13g2_decap_8
XFILLER_44_413 VPWR VGND sg13g2_decap_8
XFILLER_29_487 VPWR VGND sg13g2_decap_8
XFILLER_16_148 VPWR VGND sg13g2_decap_8
XFILLER_40_630 VPWR VGND sg13g2_decap_8
XFILLER_12_354 VPWR VGND sg13g2_decap_8
XFILLER_8_358 VPWR VGND sg13g2_decap_8
XFILLER_21_81 VPWR VGND sg13g2_decap_8
XFILLER_4_575 VPWR VGND sg13g2_decap_8
XFILLER_0_770 VPWR VGND sg13g2_decap_8
XFILLER_48_763 VPWR VGND sg13g2_decap_8
XFILLER_47_273 VPWR VGND sg13g2_decap_8
XFILLER_35_413 VPWR VGND sg13g2_decap_8
XFILLER_43_490 VPWR VGND sg13g2_decap_8
XFILLER_31_641 VPWR VGND sg13g2_decap_8
XFILLER_30_151 VPWR VGND sg13g2_decap_8
XFILLER_7_50 VPWR VGND sg13g2_decap_8
XFILLER_27_903 VPWR VGND sg13g2_decap_8
XFILLER_38_273 VPWR VGND sg13g2_decap_8
XFILLER_26_424 VPWR VGND sg13g2_decap_8
XFILLER_41_427 VPWR VGND sg13g2_decap_8
XFILLER_42_14 VPWR VGND sg13g2_decap_8
XFILLER_34_490 VPWR VGND sg13g2_decap_8
XFILLER_22_641 VPWR VGND sg13g2_decap_8
XdigitalH.g\[118\].u.inv VPWR digitalH.g\[118\].u.OUTN net35 VGND sg13g2_inv_1
XFILLER_21_151 VPWR VGND sg13g2_decap_8
XFILLER_27_1001 VPWR VGND sg13g2_decap_8
XFILLER_1_567 VPWR VGND sg13g2_decap_8
XFILLER_18_903 VPWR VGND sg13g2_fill_1
XFILLER_45_700 VPWR VGND sg13g2_decap_8
XFILLER_18_936 VPWR VGND sg13g2_fill_1
XFILLER_17_435 VPWR VGND sg13g2_decap_8
XFILLER_44_210 VPWR VGND sg13g2_decap_8
XFILLER_29_284 VPWR VGND sg13g2_decap_8
XFILLER_45_777 VPWR VGND sg13g2_decap_8
XFILLER_44_287 VPWR VGND sg13g2_decap_8
XFILLER_32_438 VPWR VGND sg13g2_decap_8
XFILLER_26_991 VPWR VGND sg13g2_decap_8
XFILLER_13_652 VPWR VGND sg13g2_decap_8
XFILLER_16_92 VPWR VGND sg13g2_decap_8
XFILLER_12_151 VPWR VGND sg13g2_decap_8
XFILLER_9_645 VPWR VGND sg13g2_decap_8
XdigitalL.g\[3\].u.inv VPWR digitalL.g\[3\].u.OUTN net71 VGND sg13g2_inv_1
XFILLER_8_155 VPWR VGND sg13g2_decap_8
XFILLER_5_862 VPWR VGND sg13g2_decap_8
XFILLER_4_372 VPWR VGND sg13g2_decap_8
XFILLER_48_560 VPWR VGND sg13g2_decap_8
XFILLER_36_700 VPWR VGND sg13g2_decap_8
XFILLER_35_210 VPWR VGND sg13g2_decap_8
XFILLER_24_928 VPWR VGND sg13g2_decap_8
XFILLER_35_287 VPWR VGND sg13g2_decap_8
XFILLER_23_438 VPWR VGND sg13g2_decap_8
XFILLER_32_961 VPWR VGND sg13g2_fill_2
XdigitalL.g\[10\].u.inv VPWR digitalL.g\[10\].u.OUTN net72 VGND sg13g2_inv_1
XFILLER_12_39 VPWR VGND sg13g2_decap_8
XFILLER_2_309 VPWR VGND sg13g2_decap_8
XFILLER_37_14 VPWR VGND sg13g2_decap_8
XFILLER_39_560 VPWR VGND sg13g2_decap_8
XFILLER_27_700 VPWR VGND sg13g2_decap_8
XFILLER_26_221 VPWR VGND sg13g2_decap_8
XFILLER_42_714 VPWR VGND sg13g2_decap_8
XFILLER_27_777 VPWR VGND sg13g2_decap_8
XFILLER_41_224 VPWR VGND sg13g2_decap_8
XFILLER_26_298 VPWR VGND sg13g2_decap_8
XFILLER_14_449 VPWR VGND sg13g2_decap_8
XFILLER_30_909 VPWR VGND sg13g2_fill_2
XFILLER_10_600 VPWR VGND sg13g2_decap_8
XdigitalL.g\[105\].u.inv VPWR digitalL.g\[105\].u.OUTN net86 VGND sg13g2_inv_1
XFILLER_10_677 VPWR VGND sg13g2_decap_8
XdigitalL.g\[74\].u.buff net108 digitalL.g\[74\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_6_659 VPWR VGND sg13g2_decap_8
XdigitalH.g\[55\].u.inv VPWR digitalH.g\[55\].u.OUTN net51 VGND sg13g2_inv_1
XFILLER_5_169 VPWR VGND sg13g2_decap_8
XFILLER_2_876 VPWR VGND sg13g2_decap_8
XFILLER_1_364 VPWR VGND sg13g2_decap_8
XFILLER_49_357 VPWR VGND sg13g2_decap_8
XFILLER_18_722 VPWR VGND sg13g2_decap_8
XFILLER_17_232 VPWR VGND sg13g2_decap_8
XFILLER_45_574 VPWR VGND sg13g2_decap_8
XFILLER_33_714 VPWR VGND sg13g2_decap_8
XFILLER_27_91 VPWR VGND sg13g2_decap_8
XFILLER_32_235 VPWR VGND sg13g2_decap_8
XFILLER_9_442 VPWR VGND sg13g2_decap_8
XFILLER_28_508 VPWR VGND sg13g2_decap_8
XFILLER_36_574 VPWR VGND sg13g2_decap_8
XFILLER_24_725 VPWR VGND sg13g2_decap_8
XFILLER_23_235 VPWR VGND sg13g2_decap_8
XFILLER_20_920 VPWR VGND sg13g2_fill_1
XFILLER_20_975 VPWR VGND sg13g2_fill_1
XFILLER_20_964 VPWR VGND sg13g2_decap_8
XFILLER_2_106 VPWR VGND sg13g2_decap_8
XFILLER_3_8 VPWR VGND sg13g2_decap_8
XFILLER_48_35 VPWR VGND sg13g2_decap_8
XFILLER_24_1026 VPWR VGND sg13g2_fill_2
XFILLER_42_511 VPWR VGND sg13g2_decap_8
XFILLER_27_574 VPWR VGND sg13g2_decap_8
XFILLER_14_246 VPWR VGND sg13g2_decap_8
XFILLER_9_29 VPWR VGND sg13g2_decap_8
XFILLER_42_588 VPWR VGND sg13g2_decap_8
XFILLER_30_739 VPWR VGND sg13g2_decap_8
Xfanout50 net54 net50 VPWR VGND sg13g2_buf_1
Xfanout61 net64 net61 VPWR VGND sg13g2_buf_1
Xfanout72 net75 net72 VPWR VGND sg13g2_buf_1
Xfanout83 net85 net83 VPWR VGND sg13g2_buf_1
XFILLER_7_902 VPWR VGND sg13g2_fill_1
XFILLER_7_924 VPWR VGND sg13g2_decap_4
Xfanout94 net96 net94 VPWR VGND sg13g2_buf_1
XFILLER_31_1008 VPWR VGND sg13g2_fill_1
XFILLER_10_474 VPWR VGND sg13g2_decap_8
XFILLER_13_71 VPWR VGND sg13g2_decap_8
XFILLER_6_456 VPWR VGND sg13g2_decap_8
XdigitalH.g\[65\].u.buff net63 digitalH.g\[65\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_673 VPWR VGND sg13g2_decap_8
XFILLER_1_161 VPWR VGND sg13g2_decap_8
XFILLER_49_154 VPWR VGND sg13g2_decap_8
XFILLER_46_861 VPWR VGND sg13g2_decap_8
XFILLER_45_371 VPWR VGND sg13g2_decap_8
XFILLER_33_511 VPWR VGND sg13g2_decap_8
XFILLER_18_596 VPWR VGND sg13g2_decap_8
XFILLER_33_588 VPWR VGND sg13g2_decap_8
XFILLER_21_739 VPWR VGND sg13g2_decap_8
XFILLER_20_249 VPWR VGND sg13g2_decap_8
XFILLER_47_1015 VPWR VGND sg13g2_decap_8
XFILLER_28_305 VPWR VGND sg13g2_decap_8
XFILLER_43_308 VPWR VGND sg13g2_decap_8
XFILLER_36_371 VPWR VGND sg13g2_decap_8
XFILLER_24_522 VPWR VGND sg13g2_decap_8
XFILLER_24_599 VPWR VGND sg13g2_decap_8
XFILLER_19_338 VPWR VGND sg13g2_decap_8
XFILLER_47_658 VPWR VGND sg13g2_decap_8
XFILLER_46_168 VPWR VGND sg13g2_decap_8
XFILLER_34_308 VPWR VGND sg13g2_decap_8
XFILLER_28_872 VPWR VGND sg13g2_decap_8
XFILLER_27_371 VPWR VGND sg13g2_decap_8
XFILLER_15_533 VPWR VGND sg13g2_decap_8
XFILLER_42_385 VPWR VGND sg13g2_decap_8
XFILLER_30_536 VPWR VGND sg13g2_decap_8
XFILLER_24_81 VPWR VGND sg13g2_decap_8
XFILLER_10_271 VPWR VGND sg13g2_decap_8
XFILLER_7_743 VPWR VGND sg13g2_decap_8
XdigitalL.g\[57\].u.inv VPWR digitalL.g\[57\].u.OUTN net104 VGND sg13g2_inv_1
XFILLER_6_253 VPWR VGND sg13g2_decap_8
XFILLER_40_91 VPWR VGND sg13g2_decap_8
XdigitalH.g\[112\].u.buff net37 digitalH.g\[112\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_960 VPWR VGND sg13g2_decap_8
XFILLER_2_470 VPWR VGND sg13g2_decap_8
XFILLER_38_658 VPWR VGND sg13g2_decap_8
XFILLER_26_809 VPWR VGND sg13g2_decap_8
XFILLER_1_63 VPWR VGND sg13g2_decap_8
XFILLER_37_168 VPWR VGND sg13g2_decap_8
XFILLER_25_319 VPWR VGND sg13g2_decap_8
XFILLER_18_393 VPWR VGND sg13g2_decap_8
XFILLER_33_385 VPWR VGND sg13g2_decap_8
XFILLER_21_536 VPWR VGND sg13g2_decap_8
XFILLER_20_39 VPWR VGND sg13g2_decap_8
XFILLER_28_102 VPWR VGND sg13g2_decap_8
XFILLER_21_1018 VPWR VGND sg13g2_decap_8
XFILLER_29_669 VPWR VGND sg13g2_decap_8
XFILLER_45_14 VPWR VGND sg13g2_decap_8
XFILLER_43_105 VPWR VGND sg13g2_decap_8
XFILLER_28_179 VPWR VGND sg13g2_decap_8
XFILLER_25_886 VPWR VGND sg13g2_decap_8
XFILLER_12_536 VPWR VGND sg13g2_decap_8
XFILLER_24_396 VPWR VGND sg13g2_decap_8
XFILLER_4_757 VPWR VGND sg13g2_decap_8
XFILLER_10_61 VPWR VGND sg13g2_decap_8
XFILLER_3_267 VPWR VGND sg13g2_decap_8
XFILLER_0_952 VPWR VGND sg13g2_decap_8
XFILLER_48_945 VPWR VGND sg13g2_decap_8
XFILLER_47_455 VPWR VGND sg13g2_decap_8
XFILLER_19_135 VPWR VGND sg13g2_decap_8
XFILLER_34_105 VPWR VGND sg13g2_decap_8
XdigitalL.g\[102\].u.buff net86 digitalL.g\[102\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_15_330 VPWR VGND sg13g2_decap_8
XFILLER_43_672 VPWR VGND sg13g2_decap_8
XFILLER_42_182 VPWR VGND sg13g2_decap_8
XFILLER_35_91 VPWR VGND sg13g2_decap_8
XdigitalH.g\[80\].u.buff net58 digitalH.g\[80\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_30_333 VPWR VGND sg13g2_decap_8
XFILLER_7_540 VPWR VGND sg13g2_decap_8
XFILLER_44_1018 VPWR VGND sg13g2_decap_8
XFILLER_38_455 VPWR VGND sg13g2_decap_8
X_08_ net115 net10 VPWR VGND sg13g2_buf_1
XFILLER_26_606 VPWR VGND sg13g2_decap_8
XFILLER_25_116 VPWR VGND sg13g2_decap_8
XFILLER_18_190 VPWR VGND sg13g2_decap_8
XFILLER_41_609 VPWR VGND sg13g2_decap_8
XFILLER_40_119 VPWR VGND sg13g2_decap_8
XFILLER_34_672 VPWR VGND sg13g2_decap_8
XFILLER_22_823 VPWR VGND sg13g2_decap_8
XFILLER_33_182 VPWR VGND sg13g2_decap_8
XFILLER_21_333 VPWR VGND sg13g2_decap_8
Xoutput16 net16 uo_out[3] VPWR VGND sg13g2_buf_1
XFILLER_1_749 VPWR VGND sg13g2_decap_8
XFILLER_0_259 VPWR VGND sg13g2_decap_8
XdigitalL.g\[99\].u.buff net88 digitalL.g\[99\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_1023 VPWR VGND sg13g2_decap_4
XdigitalH.g\[114\].u.inv VPWR digitalH.g\[114\].u.OUTN net36 VGND sg13g2_inv_1
XdigitalL.g\[28\].u.buff net83 digitalL.g\[28\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_17_617 VPWR VGND sg13g2_decap_8
XFILLER_29_466 VPWR VGND sg13g2_decap_8
XFILLER_16_127 VPWR VGND sg13g2_decap_8
XFILLER_45_959 VPWR VGND sg13g2_decap_8
XFILLER_44_469 VPWR VGND sg13g2_decap_8
XFILLER_25_683 VPWR VGND sg13g2_decap_8
XFILLER_12_333 VPWR VGND sg13g2_decap_8
XFILLER_24_193 VPWR VGND sg13g2_decap_8
XFILLER_8_337 VPWR VGND sg13g2_decap_8
XFILLER_40_686 VPWR VGND sg13g2_decap_8
XFILLER_21_60 VPWR VGND sg13g2_decap_8
XFILLER_4_554 VPWR VGND sg13g2_decap_8
XFILLER_48_742 VPWR VGND sg13g2_decap_8
XFILLER_47_252 VPWR VGND sg13g2_decap_8
XFILLER_35_469 VPWR VGND sg13g2_decap_8
XFILLER_16_694 VPWR VGND sg13g2_decap_8
XFILLER_31_620 VPWR VGND sg13g2_decap_8
XFILLER_30_130 VPWR VGND sg13g2_decap_8
XFILLER_31_697 VPWR VGND sg13g2_decap_8
XFILLER_38_252 VPWR VGND sg13g2_decap_8
XFILLER_26_403 VPWR VGND sg13g2_decap_8
XFILLER_27_959 VPWR VGND sg13g2_decap_8
XFILLER_41_406 VPWR VGND sg13g2_decap_8
XFILLER_22_620 VPWR VGND sg13g2_decap_8
XFILLER_21_130 VPWR VGND sg13g2_decap_8
XFILLER_6_819 VPWR VGND sg13g2_decap_8
XFILLER_22_697 VPWR VGND sg13g2_decap_8
XdigitalL.g\[101\].u.inv VPWR digitalL.g\[101\].u.OUTN net88 VGND sg13g2_inv_1
XFILLER_1_546 VPWR VGND sg13g2_decap_8
XFILLER_49_539 VPWR VGND sg13g2_decap_8
XFILLER_29_263 VPWR VGND sg13g2_decap_8
XFILLER_17_414 VPWR VGND sg13g2_decap_8
XdigitalH.g\[19\].u.buff net29 digitalH.g\[19\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[51\].u.inv VPWR digitalH.g\[51\].u.OUTN net50 VGND sg13g2_inv_1
XFILLER_45_756 VPWR VGND sg13g2_decap_8
XFILLER_16_71 VPWR VGND sg13g2_decap_8
XFILLER_44_266 VPWR VGND sg13g2_decap_8
XFILLER_32_417 VPWR VGND sg13g2_decap_8
XFILLER_26_970 VPWR VGND sg13g2_decap_8
XFILLER_13_631 VPWR VGND sg13g2_decap_8
XFILLER_25_480 VPWR VGND sg13g2_decap_8
XFILLER_12_130 VPWR VGND sg13g2_decap_8
XFILLER_9_624 VPWR VGND sg13g2_decap_8
XFILLER_8_134 VPWR VGND sg13g2_decap_8
XFILLER_40_483 VPWR VGND sg13g2_decap_8
XFILLER_32_81 VPWR VGND sg13g2_decap_8
XFILLER_5_841 VPWR VGND sg13g2_decap_8
XFILLER_4_351 VPWR VGND sg13g2_decap_8
XFILLER_24_907 VPWR VGND sg13g2_decap_8
XFILLER_35_266 VPWR VGND sg13g2_decap_8
XFILLER_23_417 VPWR VGND sg13g2_decap_8
XFILLER_16_491 VPWR VGND sg13g2_decap_8
XFILLER_12_18 VPWR VGND sg13g2_decap_8
XFILLER_31_494 VPWR VGND sg13g2_decap_8
XFILLER_26_200 VPWR VGND sg13g2_decap_8
XFILLER_27_756 VPWR VGND sg13g2_decap_8
XFILLER_14_428 VPWR VGND sg13g2_decap_8
XFILLER_41_203 VPWR VGND sg13g2_decap_8
XFILLER_26_277 VPWR VGND sg13g2_decap_8
XFILLER_23_984 VPWR VGND sg13g2_decap_8
XFILLER_22_494 VPWR VGND sg13g2_decap_8
XFILLER_10_656 VPWR VGND sg13g2_decap_8
XFILLER_6_638 VPWR VGND sg13g2_decap_8
XFILLER_5_148 VPWR VGND sg13g2_decap_8
XdigitalL.g\[43\].u.buff net94 digitalL.g\[43\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_855 VPWR VGND sg13g2_decap_8
XFILLER_1_343 VPWR VGND sg13g2_decap_8
XFILLER_49_336 VPWR VGND sg13g2_decap_8
XFILLER_18_701 VPWR VGND sg13g2_decap_8
XFILLER_17_211 VPWR VGND sg13g2_decap_8
XFILLER_45_553 VPWR VGND sg13g2_decap_8
XFILLER_27_70 VPWR VGND sg13g2_decap_8
XFILLER_18_767 VPWR VGND sg13g2_fill_1
XFILLER_17_288 VPWR VGND sg13g2_decap_8
XFILLER_32_214 VPWR VGND sg13g2_decap_8
XFILLER_9_421 VPWR VGND sg13g2_decap_8
XFILLER_43_91 VPWR VGND sg13g2_decap_8
XFILLER_40_280 VPWR VGND sg13g2_decap_8
XFILLER_9_498 VPWR VGND sg13g2_decap_8
XFILLER_4_85 VPWR VGND sg13g2_decap_8
XFILLER_36_553 VPWR VGND sg13g2_decap_8
XFILLER_24_704 VPWR VGND sg13g2_decap_8
XFILLER_23_214 VPWR VGND sg13g2_decap_8
XFILLER_32_792 VPWR VGND sg13g2_fill_1
XFILLER_23_39 VPWR VGND sg13g2_decap_8
XFILLER_20_932 VPWR VGND sg13g2_decap_8
XFILLER_31_291 VPWR VGND sg13g2_decap_8
XFILLER_48_14 VPWR VGND sg13g2_decap_8
XFILLER_24_1005 VPWR VGND sg13g2_decap_8
XFILLER_27_553 VPWR VGND sg13g2_decap_8
XFILLER_15_715 VPWR VGND sg13g2_decap_8
XFILLER_15_726 VPWR VGND sg13g2_fill_1
XFILLER_14_225 VPWR VGND sg13g2_decap_8
Xfanout40 net43 net40 VPWR VGND sg13g2_buf_1
XFILLER_42_567 VPWR VGND sg13g2_decap_8
XFILLER_30_718 VPWR VGND sg13g2_decap_8
Xfanout51 net54 net51 VPWR VGND sg13g2_buf_1
Xfanout62 net64 net62 VPWR VGND sg13g2_buf_1
Xfanout73 net75 net73 VPWR VGND sg13g2_buf_1
XFILLER_23_781 VPWR VGND sg13g2_decap_8
XFILLER_10_453 VPWR VGND sg13g2_decap_8
XFILLER_13_50 VPWR VGND sg13g2_decap_8
Xfanout84 net85 net84 VPWR VGND sg13g2_buf_1
Xfanout95 net96 net95 VPWR VGND sg13g2_buf_1
XFILLER_22_291 VPWR VGND sg13g2_decap_8
XFILLER_6_435 VPWR VGND sg13g2_decap_8
XFILLER_7_969 VPWR VGND sg13g2_fill_1
XdigitalL.g\[127\].u.buff net69 digitalL.g\[127\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_652 VPWR VGND sg13g2_decap_8
XFILLER_1_140 VPWR VGND sg13g2_decap_8
XdigitalH.g\[34\].u.buff net46 digitalH.g\[34\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[53\].u.inv VPWR digitalL.g\[53\].u.OUTN net103 VGND sg13g2_inv_1
XFILLER_49_133 VPWR VGND sg13g2_decap_8
XFILLER_46_840 VPWR VGND sg13g2_decap_8
XFILLER_38_91 VPWR VGND sg13g2_decap_8
XFILLER_45_350 VPWR VGND sg13g2_decap_8
XFILLER_18_575 VPWR VGND sg13g2_decap_8
XFILLER_33_567 VPWR VGND sg13g2_decap_8
XFILLER_21_718 VPWR VGND sg13g2_decap_8
XFILLER_20_228 VPWR VGND sg13g2_decap_8
XFILLER_9_295 VPWR VGND sg13g2_decap_8
XFILLER_48_0 VPWR VGND sg13g2_decap_8
XdigitalH.g\[98\].u.inv VPWR digitalH.g\[98\].u.OUTN net41 VGND sg13g2_inv_1
XFILLER_36_350 VPWR VGND sg13g2_decap_8
XFILLER_24_501 VPWR VGND sg13g2_decap_8
XFILLER_12_718 VPWR VGND sg13g2_decap_8
XFILLER_34_49 VPWR VGND sg13g2_decap_8
XFILLER_24_578 VPWR VGND sg13g2_decap_8
XFILLER_11_239 VPWR VGND sg13g2_decap_8
XFILLER_20_784 VPWR VGND sg13g2_decap_8
XFILLER_4_939 VPWR VGND sg13g2_decap_8
XFILLER_3_449 VPWR VGND sg13g2_decap_8
XFILLER_47_637 VPWR VGND sg13g2_decap_8
XFILLER_19_317 VPWR VGND sg13g2_decap_8
XFILLER_46_147 VPWR VGND sg13g2_decap_8
XFILLER_28_851 VPWR VGND sg13g2_decap_8
XFILLER_15_512 VPWR VGND sg13g2_decap_8
XFILLER_27_350 VPWR VGND sg13g2_decap_8
XFILLER_42_364 VPWR VGND sg13g2_decap_8
XFILLER_15_589 VPWR VGND sg13g2_decap_8
XFILLER_30_515 VPWR VGND sg13g2_decap_8
XFILLER_24_60 VPWR VGND sg13g2_decap_8
XdigitalH.g\[109\].u.inv VPWR digitalH.g\[109\].u.OUTN net39 VGND sg13g2_inv_1
XFILLER_10_250 VPWR VGND sg13g2_decap_8
XFILLER_7_722 VPWR VGND sg13g2_decap_8
XFILLER_6_232 VPWR VGND sg13g2_decap_8
XFILLER_40_70 VPWR VGND sg13g2_decap_8
XFILLER_41_7 VPWR VGND sg13g2_decap_8
XFILLER_38_637 VPWR VGND sg13g2_decap_8
XFILLER_37_147 VPWR VGND sg13g2_decap_8
XFILLER_1_42 VPWR VGND sg13g2_decap_8
XFILLER_19_895 VPWR VGND sg13g2_fill_1
XFILLER_18_372 VPWR VGND sg13g2_decap_8
XFILLER_33_364 VPWR VGND sg13g2_decap_8
XFILLER_21_515 VPWR VGND sg13g2_decap_8
XFILLER_20_18 VPWR VGND sg13g2_decap_8
XFILLER_29_648 VPWR VGND sg13g2_decap_8
XFILLER_16_309 VPWR VGND sg13g2_decap_8
XFILLER_28_158 VPWR VGND sg13g2_decap_8
XFILLER_25_865 VPWR VGND sg13g2_decap_8
XFILLER_12_515 VPWR VGND sg13g2_decap_8
XFILLER_24_375 VPWR VGND sg13g2_decap_8
XFILLER_8_519 VPWR VGND sg13g2_decap_8
XdigitalH.g\[110\].u.inv VPWR digitalH.g\[110\].u.OUTN net37 VGND sg13g2_inv_1
XFILLER_20_592 VPWR VGND sg13g2_decap_8
XFILLER_4_736 VPWR VGND sg13g2_decap_8
XFILLER_10_40 VPWR VGND sg13g2_decap_8
XFILLER_3_246 VPWR VGND sg13g2_decap_8
XFILLER_0_931 VPWR VGND sg13g2_decap_8
XFILLER_48_924 VPWR VGND sg13g2_decap_8
XFILLER_19_114 VPWR VGND sg13g2_decap_8
XFILLER_47_434 VPWR VGND sg13g2_decap_8
XFILLER_19_93 VPWR VGND sg13g2_decap_8
XFILLER_43_651 VPWR VGND sg13g2_decap_8
XFILLER_35_70 VPWR VGND sg13g2_decap_8
XFILLER_15_386 VPWR VGND sg13g2_decap_8
XFILLER_42_161 VPWR VGND sg13g2_decap_8
XFILLER_31_835 VPWR VGND sg13g2_fill_1
XFILLER_31_824 VPWR VGND sg13g2_fill_1
XFILLER_30_312 VPWR VGND sg13g2_decap_8
XFILLER_30_389 VPWR VGND sg13g2_decap_8
XdigitalH.g\[46\].u.inv VPWR digitalH.g\[46\].u.OUTN net48 VGND sg13g2_inv_1
XFILLER_7_596 VPWR VGND sg13g2_decap_8
XFILLER_38_434 VPWR VGND sg13g2_decap_8
XFILLER_19_681 VPWR VGND sg13g2_decap_8
XFILLER_15_29 VPWR VGND sg13g2_decap_8
XFILLER_34_651 VPWR VGND sg13g2_decap_8
XFILLER_22_802 VPWR VGND sg13g2_decap_8
XFILLER_33_161 VPWR VGND sg13g2_decap_8
XFILLER_21_312 VPWR VGND sg13g2_decap_8
XFILLER_22_879 VPWR VGND sg13g2_decap_8
XFILLER_21_389 VPWR VGND sg13g2_decap_8
XFILLER_31_39 VPWR VGND sg13g2_decap_8
Xoutput17 net17 uo_out[4] VPWR VGND sg13g2_buf_1
XFILLER_1_728 VPWR VGND sg13g2_decap_8
XFILLER_0_238 VPWR VGND sg13g2_decap_8
XFILLER_5_1002 VPWR VGND sg13g2_decap_8
XFILLER_29_445 VPWR VGND sg13g2_decap_8
XFILLER_45_938 VPWR VGND sg13g2_decap_8
XFILLER_16_106 VPWR VGND sg13g2_decap_8
XdigitalL.g\[68\].u.buff net109 digitalL.g\[68\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_44_448 VPWR VGND sg13g2_decap_8
XFILLER_25_662 VPWR VGND sg13g2_decap_8
XFILLER_12_312 VPWR VGND sg13g2_decap_8
XFILLER_31_109 VPWR VGND sg13g2_decap_8
XFILLER_24_172 VPWR VGND sg13g2_decap_8
XFILLER_8_316 VPWR VGND sg13g2_decap_8
XFILLER_40_665 VPWR VGND sg13g2_decap_8
XFILLER_12_389 VPWR VGND sg13g2_decap_8
XFILLER_21_890 VPWR VGND sg13g2_fill_1
XFILLER_4_533 VPWR VGND sg13g2_decap_8
XFILLER_48_721 VPWR VGND sg13g2_decap_8
XFILLER_11_8 VPWR VGND sg13g2_decap_8
XFILLER_47_231 VPWR VGND sg13g2_decap_8
XFILLER_48_798 VPWR VGND sg13g2_decap_8
XFILLER_46_91 VPWR VGND sg13g2_decap_8
XFILLER_35_448 VPWR VGND sg13g2_decap_8
XFILLER_16_673 VPWR VGND sg13g2_decap_8
XFILLER_22_109 VPWR VGND sg13g2_decap_8
XFILLER_15_183 VPWR VGND sg13g2_decap_8
XFILLER_31_676 VPWR VGND sg13g2_decap_8
XFILLER_30_186 VPWR VGND sg13g2_decap_8
XFILLER_7_393 VPWR VGND sg13g2_decap_8
XFILLER_7_85 VPWR VGND sg13g2_decap_8
XFILLER_39_721 VPWR VGND sg13g2_decap_8
XFILLER_38_231 VPWR VGND sg13g2_decap_8
XFILLER_27_938 VPWR VGND sg13g2_decap_8
XFILLER_26_39 VPWR VGND sg13g2_decap_8
XFILLER_42_919 VPWR VGND sg13g2_fill_2
XFILLER_26_459 VPWR VGND sg13g2_decap_8
XFILLER_42_49 VPWR VGND sg13g2_decap_8
XFILLER_22_676 VPWR VGND sg13g2_decap_8
XFILLER_21_186 VPWR VGND sg13g2_decap_8
XFILLER_1_525 VPWR VGND sg13g2_decap_8
XFILLER_49_518 VPWR VGND sg13g2_decap_8
XFILLER_29_242 VPWR VGND sg13g2_decap_8
XFILLER_18_927 VPWR VGND sg13g2_fill_2
XFILLER_18_916 VPWR VGND sg13g2_fill_1
XFILLER_45_735 VPWR VGND sg13g2_decap_8
XFILLER_44_245 VPWR VGND sg13g2_decap_8
XFILLER_13_610 VPWR VGND sg13g2_decap_8
XFILLER_16_50 VPWR VGND sg13g2_decap_8
XdigitalH.g\[59\].u.buff net52 digitalH.g\[59\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_9_603 VPWR VGND sg13g2_decap_8
XFILLER_40_462 VPWR VGND sg13g2_decap_8
XFILLER_12_186 VPWR VGND sg13g2_decap_8
XFILLER_13_687 VPWR VGND sg13g2_decap_8
XFILLER_8_113 VPWR VGND sg13g2_decap_8
XFILLER_32_60 VPWR VGND sg13g2_decap_8
XFILLER_5_820 VPWR VGND sg13g2_decap_8
XFILLER_4_330 VPWR VGND sg13g2_decap_8
XFILLER_5_897 VPWR VGND sg13g2_decap_8
XFILLER_48_595 VPWR VGND sg13g2_decap_8
XFILLER_36_735 VPWR VGND sg13g2_decap_4
XFILLER_35_245 VPWR VGND sg13g2_decap_8
XFILLER_16_470 VPWR VGND sg13g2_decap_8
XFILLER_31_473 VPWR VGND sg13g2_decap_8
XdigitalL.g\[48\].u.inv VPWR digitalL.g\[48\].u.OUTN net95 VGND sg13g2_inv_1
XFILLER_8_680 VPWR VGND sg13g2_decap_8
XFILLER_7_190 VPWR VGND sg13g2_decap_8
XFILLER_37_49 VPWR VGND sg13g2_decap_8
XFILLER_39_595 VPWR VGND sg13g2_decap_8
XFILLER_2_1027 VPWR VGND sg13g2_fill_2
XFILLER_2_1016 VPWR VGND sg13g2_decap_8
XFILLER_27_735 VPWR VGND sg13g2_decap_8
XFILLER_14_407 VPWR VGND sg13g2_decap_8
XFILLER_26_256 VPWR VGND sg13g2_decap_8
XFILLER_41_259 VPWR VGND sg13g2_decap_8
XFILLER_23_963 VPWR VGND sg13g2_decap_8
XFILLER_10_635 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[1\].u.inv VPWR digitalenH.g\[1\].u.OUTN net4 VGND sg13g2_inv_1
XFILLER_22_473 VPWR VGND sg13g2_decap_8
XFILLER_6_617 VPWR VGND sg13g2_decap_8
XFILLER_5_127 VPWR VGND sg13g2_decap_8
XFILLER_2_834 VPWR VGND sg13g2_decap_8
XFILLER_1_322 VPWR VGND sg13g2_decap_8
XFILLER_49_315 VPWR VGND sg13g2_decap_8
XdigitalL.g\[83\].u.buff net99 digitalL.g\[83\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_1_399 VPWR VGND sg13g2_decap_8
XdigitalL.g\[12\].u.buff net73 digitalL.g\[12\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_532 VPWR VGND sg13g2_decap_8
XFILLER_17_267 VPWR VGND sg13g2_decap_8
XFILLER_33_738 VPWR VGND sg13g2_fill_1
XdigitalH.g\[7\].u.buff net24 digitalH.g\[7\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_9_400 VPWR VGND sg13g2_decap_8
XFILLER_13_484 VPWR VGND sg13g2_decap_8
XdigitalH.g\[106\].u.buff net39 digitalH.g\[106\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_70 VPWR VGND sg13g2_decap_8
XFILLER_9_477 VPWR VGND sg13g2_decap_8
XFILLER_5_694 VPWR VGND sg13g2_decap_8
XFILLER_4_64 VPWR VGND sg13g2_decap_8
XFILLER_49_882 VPWR VGND sg13g2_decap_8
XFILLER_48_392 VPWR VGND sg13g2_decap_8
XFILLER_36_532 VPWR VGND sg13g2_decap_8
XFILLER_23_18 VPWR VGND sg13g2_decap_8
XFILLER_31_270 VPWR VGND sg13g2_decap_8
XFILLER_20_944 VPWR VGND sg13g2_decap_8
XFILLER_20_955 VPWR VGND sg13g2_fill_1
XdigitalH.g\[94\].u.inv VPWR digitalH.g\[94\].u.OUTN net42 VGND sg13g2_inv_1
XFILLER_47_819 VPWR VGND sg13g2_decap_8
XFILLER_24_1028 VPWR VGND sg13g2_fill_1
XFILLER_46_329 VPWR VGND sg13g2_decap_8
XFILLER_39_392 VPWR VGND sg13g2_decap_8
XFILLER_27_532 VPWR VGND sg13g2_decap_8
XFILLER_14_204 VPWR VGND sg13g2_decap_8
XFILLER_42_546 VPWR VGND sg13g2_decap_8
Xfanout30 net31 net30 VPWR VGND sg13g2_buf_1
XFILLER_23_760 VPWR VGND sg13g2_decap_8
Xfanout41 net43 net41 VPWR VGND sg13g2_buf_1
Xfanout52 net54 net52 VPWR VGND sg13g2_buf_1
Xfanout63 net64 net63 VPWR VGND sg13g2_buf_1
Xfanout74 net75 net74 VPWR VGND sg13g2_buf_1
XFILLER_22_270 VPWR VGND sg13g2_decap_8
XFILLER_10_432 VPWR VGND sg13g2_decap_8
Xfanout85 net91 net85 VPWR VGND sg13g2_buf_1
Xfanout96 net113 net96 VPWR VGND sg13g2_buf_1
XFILLER_6_414 VPWR VGND sg13g2_decap_8
XFILLER_7_948 VPWR VGND sg13g2_fill_1
XFILLER_2_631 VPWR VGND sg13g2_decap_8
XFILLER_49_112 VPWR VGND sg13g2_decap_8
XdigitalH.g\[105\].u.inv VPWR digitalH.g\[105\].u.OUTN net40 VGND sg13g2_inv_1
XFILLER_1_196 VPWR VGND sg13g2_decap_8
XFILLER_49_189 VPWR VGND sg13g2_decap_8
XFILLER_38_70 VPWR VGND sg13g2_decap_8
XFILLER_37_329 VPWR VGND sg13g2_decap_8
XdigitalH.g\[74\].u.buff net61 digitalH.g\[74\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_896 VPWR VGND sg13g2_decap_8
XFILLER_18_554 VPWR VGND sg13g2_decap_8
XFILLER_33_546 VPWR VGND sg13g2_decap_8
XFILLER_20_207 VPWR VGND sg13g2_decap_8
XFILLER_13_281 VPWR VGND sg13g2_decap_8
XFILLER_9_274 VPWR VGND sg13g2_decap_8
XFILLER_6_970 VPWR VGND sg13g2_fill_2
XFILLER_5_491 VPWR VGND sg13g2_decap_8
XFILLER_18_29 VPWR VGND sg13g2_decap_8
XFILLER_34_28 VPWR VGND sg13g2_decap_8
XFILLER_24_557 VPWR VGND sg13g2_decap_8
XFILLER_11_218 VPWR VGND sg13g2_decap_8
XFILLER_4_918 VPWR VGND sg13g2_decap_8
XFILLER_3_428 VPWR VGND sg13g2_decap_8
XFILLER_1_7 VPWR VGND sg13g2_decap_8
XFILLER_47_616 VPWR VGND sg13g2_decap_8
XFILLER_46_126 VPWR VGND sg13g2_decap_8
XFILLER_28_830 VPWR VGND sg13g2_decap_8
XFILLER_15_568 VPWR VGND sg13g2_decap_8
XFILLER_42_343 VPWR VGND sg13g2_decap_8
XFILLER_7_701 VPWR VGND sg13g2_decap_8
XFILLER_6_211 VPWR VGND sg13g2_decap_8
XFILLER_7_789 VPWR VGND sg13g2_fill_1
XFILLER_6_288 VPWR VGND sg13g2_decap_8
XFILLER_3_995 VPWR VGND sg13g2_decap_8
XFILLER_34_7 VPWR VGND sg13g2_decap_8
XFILLER_49_91 VPWR VGND sg13g2_decap_8
XFILLER_38_616 VPWR VGND sg13g2_decap_8
XFILLER_1_21 VPWR VGND sg13g2_decap_8
X_23_ net115 net9 VPWR VGND sg13g2_buf_1
XFILLER_37_126 VPWR VGND sg13g2_decap_8
XFILLER_19_841 VPWR VGND sg13g2_fill_1
XdigitalH.g\[42\].u.inv VPWR digitalH.g\[42\].u.OUTN net47 VGND sg13g2_inv_1
XFILLER_1_98 VPWR VGND sg13g2_decap_8
XFILLER_19_874 VPWR VGND sg13g2_fill_1
XFILLER_18_351 VPWR VGND sg13g2_decap_8
XdigitalH.g\[121\].u.buff net33 digitalH.g\[121\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_693 VPWR VGND sg13g2_decap_8
XFILLER_33_343 VPWR VGND sg13g2_decap_8
XFILLER_29_39 VPWR VGND sg13g2_decap_8
XFILLER_29_627 VPWR VGND sg13g2_decap_8
XFILLER_28_137 VPWR VGND sg13g2_decap_8
XFILLER_45_49 VPWR VGND sg13g2_decap_8
XFILLER_37_693 VPWR VGND sg13g2_decap_8
XFILLER_25_844 VPWR VGND sg13g2_decap_8
XFILLER_24_354 VPWR VGND sg13g2_decap_8
XdigitalL.g\[96\].u.inv VPWR digitalL.g\[96\].u.OUTN net89 VGND sg13g2_inv_1
XFILLER_20_571 VPWR VGND sg13g2_decap_8
XFILLER_4_715 VPWR VGND sg13g2_decap_8
XFILLER_3_225 VPWR VGND sg13g2_decap_8
XFILLER_0_910 VPWR VGND sg13g2_decap_8
XFILLER_10_96 VPWR VGND sg13g2_decap_8
XFILLER_48_903 VPWR VGND sg13g2_decap_8
XFILLER_0_987 VPWR VGND sg13g2_decap_8
XFILLER_47_413 VPWR VGND sg13g2_decap_8
XFILLER_19_72 VPWR VGND sg13g2_decap_8
XFILLER_43_630 VPWR VGND sg13g2_decap_8
XFILLER_15_365 VPWR VGND sg13g2_decap_8
XFILLER_42_140 VPWR VGND sg13g2_decap_8
XFILLER_30_368 VPWR VGND sg13g2_decap_8
XFILLER_11_582 VPWR VGND sg13g2_decap_8
XFILLER_7_575 VPWR VGND sg13g2_decap_8
XdigitalL.g\[111\].u.buff net79 digitalL.g\[111\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_792 VPWR VGND sg13g2_decap_8
XFILLER_32_4 VPWR VGND sg13g2_decap_8
XFILLER_38_413 VPWR VGND sg13g2_decap_8
XFILLER_19_660 VPWR VGND sg13g2_decap_8
XFILLER_47_980 VPWR VGND sg13g2_decap_8
XFILLER_46_490 VPWR VGND sg13g2_decap_8
XFILLER_34_630 VPWR VGND sg13g2_decap_8
XFILLER_33_140 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[1\].u.buff net3 digitalenL.g\[1\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_22_858 VPWR VGND sg13g2_decap_8
XFILLER_21_368 VPWR VGND sg13g2_decap_8
XFILLER_31_18 VPWR VGND sg13g2_decap_8
Xoutput18 net18 uo_out[5] VPWR VGND sg13g2_buf_1
XFILLER_1_707 VPWR VGND sg13g2_decap_8
XFILLER_0_217 VPWR VGND sg13g2_decap_8
XFILLER_29_424 VPWR VGND sg13g2_decap_8
XFILLER_45_917 VPWR VGND sg13g2_decap_8
XFILLER_44_427 VPWR VGND sg13g2_decap_8
XFILLER_37_490 VPWR VGND sg13g2_decap_8
XFILLER_25_641 VPWR VGND sg13g2_decap_8
XFILLER_24_151 VPWR VGND sg13g2_decap_8
XFILLER_40_644 VPWR VGND sg13g2_decap_8
XFILLER_12_368 VPWR VGND sg13g2_decap_8
XdigitalL.g\[37\].u.buff net92 digitalL.g\[37\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[2\].u.buff net70 digitalL.g\[2\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_512 VPWR VGND sg13g2_decap_8
XFILLER_21_95 VPWR VGND sg13g2_decap_8
XFILLER_4_589 VPWR VGND sg13g2_decap_8
XFILLER_48_700 VPWR VGND sg13g2_decap_8
XFILLER_0_784 VPWR VGND sg13g2_decap_8
XFILLER_47_210 VPWR VGND sg13g2_decap_8
XFILLER_48_777 VPWR VGND sg13g2_decap_8
XFILLER_47_287 VPWR VGND sg13g2_decap_8
XFILLER_46_70 VPWR VGND sg13g2_decap_8
XFILLER_35_427 VPWR VGND sg13g2_decap_8
XFILLER_29_991 VPWR VGND sg13g2_decap_8
XFILLER_16_652 VPWR VGND sg13g2_decap_8
XFILLER_15_162 VPWR VGND sg13g2_decap_8
XFILLER_44_983 VPWR VGND sg13g2_decap_8
XFILLER_31_655 VPWR VGND sg13g2_decap_8
XFILLER_30_165 VPWR VGND sg13g2_decap_8
XFILLER_7_64 VPWR VGND sg13g2_decap_8
XFILLER_7_372 VPWR VGND sg13g2_decap_8
XFILLER_8_884 VPWR VGND sg13g2_fill_2
XFILLER_39_700 VPWR VGND sg13g2_decap_8
XFILLER_38_210 VPWR VGND sg13g2_decap_8
XdigitalL.g\[44\].u.inv VPWR digitalL.g\[44\].u.OUTN net94 VGND sg13g2_inv_1
XFILLER_27_917 VPWR VGND sg13g2_decap_8
XFILLER_38_287 VPWR VGND sg13g2_decap_8
XFILLER_26_438 VPWR VGND sg13g2_decap_8
XFILLER_26_18 VPWR VGND sg13g2_decap_8
XFILLER_42_28 VPWR VGND sg13g2_decap_8
XFILLER_22_655 VPWR VGND sg13g2_decap_8
XFILLER_21_165 VPWR VGND sg13g2_decap_8
XFILLER_5_309 VPWR VGND sg13g2_decap_8
XFILLER_1_504 VPWR VGND sg13g2_decap_8
XFILLER_27_1015 VPWR VGND sg13g2_decap_8
XFILLER_29_221 VPWR VGND sg13g2_decap_8
XFILLER_45_714 VPWR VGND sg13g2_decap_8
XFILLER_17_449 VPWR VGND sg13g2_decap_8
XdigitalH.g\[89\].u.inv VPWR digitalH.g\[89\].u.OUTN net56 VGND sg13g2_inv_1
XFILLER_44_224 VPWR VGND sg13g2_decap_8
XFILLER_29_298 VPWR VGND sg13g2_decap_8
XFILLER_13_666 VPWR VGND sg13g2_decap_8
XFILLER_40_441 VPWR VGND sg13g2_decap_8
XFILLER_12_165 VPWR VGND sg13g2_decap_8
XFILLER_9_659 VPWR VGND sg13g2_decap_8
XdigitalH.g\[99\].u.buff net41 digitalH.g\[99\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_8_169 VPWR VGND sg13g2_decap_8
XdigitalH.g\[28\].u.buff net31 digitalH.g\[28\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_876 VPWR VGND sg13g2_decap_8
XFILLER_4_386 VPWR VGND sg13g2_decap_8
XFILLER_0_581 VPWR VGND sg13g2_decap_8
XFILLER_48_574 VPWR VGND sg13g2_decap_8
XFILLER_36_714 VPWR VGND sg13g2_decap_8
XFILLER_35_224 VPWR VGND sg13g2_decap_8
XFILLER_44_791 VPWR VGND sg13g2_decap_8
XFILLER_31_452 VPWR VGND sg13g2_decap_8
XFILLER_32_997 VPWR VGND sg13g2_fill_1
XFILLER_37_28 VPWR VGND sg13g2_decap_8
XFILLER_39_574 VPWR VGND sg13g2_decap_8
XFILLER_27_714 VPWR VGND sg13g2_decap_8
XdigitalH.g\[90\].u.inv VPWR digitalH.g\[90\].u.OUTN net56 VGND sg13g2_inv_1
XFILLER_26_235 VPWR VGND sg13g2_decap_8
XFILLER_42_728 VPWR VGND sg13g2_decap_8
XFILLER_41_238 VPWR VGND sg13g2_decap_8
XFILLER_23_942 VPWR VGND sg13g2_decap_8
XFILLER_22_452 VPWR VGND sg13g2_decap_8
XFILLER_10_614 VPWR VGND sg13g2_decap_8
XFILLER_5_106 VPWR VGND sg13g2_decap_8
XFILLER_2_813 VPWR VGND sg13g2_decap_8
XFILLER_1_301 VPWR VGND sg13g2_decap_8
XFILLER_1_378 VPWR VGND sg13g2_decap_8
XFILLER_45_511 VPWR VGND sg13g2_decap_8
XFILLER_18_736 VPWR VGND sg13g2_decap_8
XFILLER_17_246 VPWR VGND sg13g2_decap_8
XdigitalL.g\[52\].u.buff net102 digitalL.g\[52\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_588 VPWR VGND sg13g2_decap_8
XFILLER_33_728 VPWR VGND sg13g2_decap_8
XFILLER_32_249 VPWR VGND sg13g2_decap_8
XFILLER_13_463 VPWR VGND sg13g2_decap_8
XdigitalH.g\[101\].u.inv VPWR digitalH.g\[101\].u.OUTN net41 VGND sg13g2_inv_1
XFILLER_9_456 VPWR VGND sg13g2_decap_8
XFILLER_5_673 VPWR VGND sg13g2_decap_8
XFILLER_4_183 VPWR VGND sg13g2_decap_8
XFILLER_4_43 VPWR VGND sg13g2_decap_8
XFILLER_49_861 VPWR VGND sg13g2_decap_8
XFILLER_48_371 VPWR VGND sg13g2_decap_8
XFILLER_36_511 VPWR VGND sg13g2_decap_8
XFILLER_36_588 VPWR VGND sg13g2_decap_8
XFILLER_24_739 VPWR VGND sg13g2_decap_8
XFILLER_23_249 VPWR VGND sg13g2_decap_8
XFILLER_20_989 VPWR VGND sg13g2_decap_8
XdigitalH.g\[37\].u.inv VPWR digitalH.g\[37\].u.OUTN net44 VGND sg13g2_inv_1
XFILLER_48_49 VPWR VGND sg13g2_decap_8
XFILLER_46_308 VPWR VGND sg13g2_decap_8
XFILLER_39_371 VPWR VGND sg13g2_decap_8
XFILLER_27_511 VPWR VGND sg13g2_decap_8
XFILLER_42_525 VPWR VGND sg13g2_decap_8
XFILLER_27_588 VPWR VGND sg13g2_decap_8
Xfanout31 net32 net31 VPWR VGND sg13g2_buf_1
XFILLER_10_411 VPWR VGND sg13g2_decap_8
Xfanout42 net43 net42 VPWR VGND sg13g2_buf_1
Xfanout53 net54 net53 VPWR VGND sg13g2_buf_1
Xfanout64 net65 net64 VPWR VGND sg13g2_buf_1
Xfanout75 net91 net75 VPWR VGND sg13g2_buf_1
Xfanout86 net90 net86 VPWR VGND sg13g2_buf_1
Xfanout97 net101 net97 VPWR VGND sg13g2_buf_1
XFILLER_10_488 VPWR VGND sg13g2_decap_8
XFILLER_13_85 VPWR VGND sg13g2_decap_8
XFILLER_2_610 VPWR VGND sg13g2_decap_8
XFILLER_2_687 VPWR VGND sg13g2_decap_8
XFILLER_1_175 VPWR VGND sg13g2_decap_8
XFILLER_49_168 VPWR VGND sg13g2_decap_8
XFILLER_37_308 VPWR VGND sg13g2_decap_8
XFILLER_18_533 VPWR VGND sg13g2_decap_8
XFILLER_46_875 VPWR VGND sg13g2_decap_8
XFILLER_45_385 VPWR VGND sg13g2_decap_8
XFILLER_33_525 VPWR VGND sg13g2_decap_8
XdigitalH.g\[43\].u.buff net47 digitalH.g\[43\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_13_260 VPWR VGND sg13g2_decap_8
XFILLER_9_253 VPWR VGND sg13g2_decap_8
XFILLER_5_470 VPWR VGND sg13g2_decap_8
XFILLER_6_993 VPWR VGND sg13g2_decap_8
XFILLER_29_809 VPWR VGND sg13g2_decap_8
XFILLER_28_319 VPWR VGND sg13g2_decap_8
XFILLER_36_385 VPWR VGND sg13g2_decap_8
XFILLER_24_536 VPWR VGND sg13g2_decap_8
XFILLER_20_764 VPWR VGND sg13g2_fill_2
XFILLER_20_753 VPWR VGND sg13g2_decap_8
XFILLER_3_407 VPWR VGND sg13g2_decap_8
XFILLER_8_1001 VPWR VGND sg13g2_fill_1
XFILLER_46_105 VPWR VGND sg13g2_decap_8
XdigitalL.g\[92\].u.inv VPWR digitalL.g\[92\].u.OUTN net97 VGND sg13g2_inv_1
XFILLER_28_886 VPWR VGND sg13g2_decap_8
XFILLER_27_385 VPWR VGND sg13g2_decap_8
XFILLER_15_547 VPWR VGND sg13g2_decap_8
XFILLER_42_322 VPWR VGND sg13g2_decap_8
XFILLER_42_399 VPWR VGND sg13g2_decap_8
XFILLER_24_95 VPWR VGND sg13g2_decap_8
XFILLER_10_285 VPWR VGND sg13g2_decap_8
XFILLER_7_757 VPWR VGND sg13g2_fill_2
XFILLER_6_267 VPWR VGND sg13g2_decap_8
XFILLER_3_974 VPWR VGND sg13g2_decap_8
XFILLER_2_484 VPWR VGND sg13g2_decap_8
XFILLER_49_70 VPWR VGND sg13g2_decap_8
XFILLER_27_7 VPWR VGND sg13g2_decap_8
X_22_ net115 net8 VPWR VGND sg13g2_buf_1
XFILLER_37_105 VPWR VGND sg13g2_decap_8
XFILLER_1_77 VPWR VGND sg13g2_decap_8
XFILLER_19_853 VPWR VGND sg13g2_fill_1
XFILLER_18_330 VPWR VGND sg13g2_decap_8
XFILLER_46_672 VPWR VGND sg13g2_decap_8
XFILLER_45_182 VPWR VGND sg13g2_decap_8
XFILLER_33_322 VPWR VGND sg13g2_decap_8
XFILLER_33_399 VPWR VGND sg13g2_decap_8
XFILLER_6_790 VPWR VGND sg13g2_decap_4
XFILLER_29_18 VPWR VGND sg13g2_decap_8
XFILLER_29_606 VPWR VGND sg13g2_decap_8
XFILLER_28_116 VPWR VGND sg13g2_decap_8
XFILLER_45_28 VPWR VGND sg13g2_decap_8
XFILLER_44_609 VPWR VGND sg13g2_decap_8
XFILLER_43_119 VPWR VGND sg13g2_decap_8
XFILLER_37_672 VPWR VGND sg13g2_decap_8
XFILLER_25_823 VPWR VGND sg13g2_decap_8
XFILLER_36_182 VPWR VGND sg13g2_decap_8
XFILLER_24_333 VPWR VGND sg13g2_decap_8
XFILLER_20_550 VPWR VGND sg13g2_decap_8
XdigitalL.g\[39\].u.inv VPWR digitalL.g\[39\].u.OUTN net93 VGND sg13g2_inv_1
XFILLER_3_204 VPWR VGND sg13g2_decap_8
XFILLER_10_75 VPWR VGND sg13g2_decap_8
XFILLER_0_966 VPWR VGND sg13g2_decap_8
XFILLER_48_959 VPWR VGND sg13g2_decap_8
XFILLER_19_51 VPWR VGND sg13g2_decap_8
XFILLER_47_469 VPWR VGND sg13g2_decap_8
XFILLER_35_609 VPWR VGND sg13g2_decap_8
XFILLER_19_149 VPWR VGND sg13g2_decap_8
XFILLER_34_119 VPWR VGND sg13g2_decap_8
XFILLER_28_683 VPWR VGND sg13g2_decap_8
XFILLER_15_344 VPWR VGND sg13g2_decap_8
XFILLER_27_182 VPWR VGND sg13g2_decap_8
XFILLER_43_686 VPWR VGND sg13g2_decap_8
XFILLER_31_815 VPWR VGND sg13g2_decap_4
XFILLER_42_196 VPWR VGND sg13g2_decap_8
XFILLER_31_848 VPWR VGND sg13g2_decap_4
XFILLER_30_347 VPWR VGND sg13g2_decap_8
XFILLER_11_561 VPWR VGND sg13g2_decap_8
XFILLER_7_554 VPWR VGND sg13g2_decap_8
XFILLER_3_771 VPWR VGND sg13g2_decap_8
XFILLER_2_281 VPWR VGND sg13g2_decap_8
XFILLER_25_4 VPWR VGND sg13g2_decap_8
XFILLER_38_469 VPWR VGND sg13g2_decap_8
XFILLER_20_1010 VPWR VGND sg13g2_decap_8
XFILLER_34_686 VPWR VGND sg13g2_decap_8
XFILLER_33_196 VPWR VGND sg13g2_decap_8
XFILLER_22_837 VPWR VGND sg13g2_decap_8
XFILLER_21_347 VPWR VGND sg13g2_decap_8
XdigitalL.g\[40\].u.inv VPWR digitalL.g\[40\].u.OUTN net93 VGND sg13g2_inv_1
XFILLER_30_870 VPWR VGND sg13g2_decap_4
Xoutput19 net19 uo_out[6] VPWR VGND sg13g2_buf_1
XFILLER_29_403 VPWR VGND sg13g2_decap_8
XFILLER_44_406 VPWR VGND sg13g2_decap_8
XFILLER_25_620 VPWR VGND sg13g2_decap_8
XFILLER_24_130 VPWR VGND sg13g2_decap_8
XFILLER_40_623 VPWR VGND sg13g2_decap_8
XFILLER_25_697 VPWR VGND sg13g2_decap_8
XFILLER_12_347 VPWR VGND sg13g2_decap_8
XdigitalL.g\[77\].u.buff net107 digitalL.g\[77\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_568 VPWR VGND sg13g2_decap_8
XdigitalH.g\[85\].u.inv VPWR digitalH.g\[85\].u.OUTN net57 VGND sg13g2_inv_1
XFILLER_21_74 VPWR VGND sg13g2_decap_8
XFILLER_0_763 VPWR VGND sg13g2_decap_8
XFILLER_43_1021 VPWR VGND sg13g2_decap_8
XFILLER_48_756 VPWR VGND sg13g2_decap_8
XFILLER_47_266 VPWR VGND sg13g2_decap_8
XFILLER_35_406 VPWR VGND sg13g2_decap_8
XFILLER_29_970 VPWR VGND sg13g2_decap_8
XFILLER_16_631 VPWR VGND sg13g2_decap_8
XFILLER_28_480 VPWR VGND sg13g2_decap_8
XFILLER_15_141 VPWR VGND sg13g2_decap_8
XFILLER_44_962 VPWR VGND sg13g2_decap_8
XFILLER_43_483 VPWR VGND sg13g2_decap_8
XFILLER_31_634 VPWR VGND sg13g2_decap_8
XFILLER_30_144 VPWR VGND sg13g2_decap_8
XFILLER_7_351 VPWR VGND sg13g2_decap_8
XFILLER_7_43 VPWR VGND sg13g2_decap_8
XFILLER_38_266 VPWR VGND sg13g2_decap_8
XFILLER_26_417 VPWR VGND sg13g2_decap_8
XFILLER_34_483 VPWR VGND sg13g2_decap_8
XFILLER_22_634 VPWR VGND sg13g2_decap_8
XFILLER_21_144 VPWR VGND sg13g2_decap_8
XFILLER_29_200 VPWR VGND sg13g2_decap_8
XFILLER_18_907 VPWR VGND sg13g2_fill_1
XFILLER_17_428 VPWR VGND sg13g2_decap_8
XFILLER_44_203 VPWR VGND sg13g2_decap_8
XFILLER_29_277 VPWR VGND sg13g2_decap_8
XFILLER_26_984 VPWR VGND sg13g2_decap_8
XFILLER_16_85 VPWR VGND sg13g2_decap_8
XFILLER_40_420 VPWR VGND sg13g2_decap_8
XFILLER_25_494 VPWR VGND sg13g2_decap_8
XFILLER_12_144 VPWR VGND sg13g2_decap_8
XFILLER_13_645 VPWR VGND sg13g2_decap_8
XFILLER_9_638 VPWR VGND sg13g2_decap_8
XFILLER_8_148 VPWR VGND sg13g2_decap_8
XFILLER_40_497 VPWR VGND sg13g2_decap_8
XFILLER_32_95 VPWR VGND sg13g2_decap_8
XFILLER_5_855 VPWR VGND sg13g2_decap_8
XFILLER_4_365 VPWR VGND sg13g2_decap_8
XdigitalH.g\[68\].u.buff net62 digitalH.g\[68\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_0_560 VPWR VGND sg13g2_decap_8
XFILLER_48_553 VPWR VGND sg13g2_decap_8
XFILLER_35_203 VPWR VGND sg13g2_decap_8
XFILLER_44_770 VPWR VGND sg13g2_decap_8
XFILLER_43_280 VPWR VGND sg13g2_decap_8
XFILLER_31_431 VPWR VGND sg13g2_decap_8
XFILLER_39_553 VPWR VGND sg13g2_decap_8
XdigitalH.g\[33\].u.inv VPWR digitalH.g\[33\].u.OUTN net44 VGND sg13g2_inv_1
XFILLER_26_214 VPWR VGND sg13g2_decap_8
XFILLER_42_707 VPWR VGND sg13g2_decap_8
XFILLER_41_217 VPWR VGND sg13g2_decap_8
XFILLER_23_921 VPWR VGND sg13g2_decap_8
XFILLER_34_280 VPWR VGND sg13g2_decap_8
XFILLER_22_431 VPWR VGND sg13g2_decap_8
XFILLER_23_998 VPWR VGND sg13g2_decap_8
XFILLER_2_869 VPWR VGND sg13g2_decap_8
XFILLER_1_357 VPWR VGND sg13g2_decap_8
XFILLER_18_715 VPWR VGND sg13g2_decap_8
XFILLER_17_225 VPWR VGND sg13g2_decap_8
XFILLER_45_567 VPWR VGND sg13g2_decap_8
XFILLER_33_707 VPWR VGND sg13g2_decap_8
XFILLER_27_84 VPWR VGND sg13g2_decap_8
XFILLER_32_228 VPWR VGND sg13g2_decap_8
XFILLER_26_781 VPWR VGND sg13g2_decap_8
XFILLER_13_442 VPWR VGND sg13g2_decap_8
XdigitalL.g\[92\].u.buff net97 digitalL.g\[92\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_25_291 VPWR VGND sg13g2_decap_8
XFILLER_9_435 VPWR VGND sg13g2_decap_8
XdigitalL.g\[21\].u.buff net81 digitalL.g\[21\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_40_294 VPWR VGND sg13g2_decap_8
XdigitalL.g\[87\].u.inv VPWR digitalL.g\[87\].u.OUTN net97 VGND sg13g2_inv_1
XFILLER_5_652 VPWR VGND sg13g2_decap_8
XFILLER_4_162 VPWR VGND sg13g2_decap_8
XFILLER_4_22 VPWR VGND sg13g2_decap_8
XdigitalH.g\[115\].u.buff net36 digitalH.g\[115\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_99 VPWR VGND sg13g2_decap_8
XFILLER_49_840 VPWR VGND sg13g2_decap_8
XFILLER_48_350 VPWR VGND sg13g2_decap_8
XFILLER_36_567 VPWR VGND sg13g2_decap_8
XFILLER_24_718 VPWR VGND sg13g2_decap_8
XFILLER_23_228 VPWR VGND sg13g2_decap_8
XFILLER_32_762 VPWR VGND sg13g2_fill_2
XFILLER_48_28 VPWR VGND sg13g2_decap_8
XFILLER_24_1019 VPWR VGND sg13g2_decap_8
XFILLER_39_350 VPWR VGND sg13g2_decap_8
XFILLER_42_504 VPWR VGND sg13g2_decap_8
XFILLER_27_567 VPWR VGND sg13g2_decap_8
XFILLER_14_239 VPWR VGND sg13g2_decap_8
Xfanout21 net23 net21 VPWR VGND sg13g2_buf_1
Xfanout32 net67 net32 VPWR VGND sg13g2_buf_1
Xfanout43 net67 net43 VPWR VGND sg13g2_buf_1
Xfanout54 net66 net54 VPWR VGND sg13g2_buf_1
Xfanout65 net66 net65 VPWR VGND sg13g2_buf_1
Xfanout76 net77 net76 VPWR VGND sg13g2_buf_1
Xfanout87 net90 net87 VPWR VGND sg13g2_buf_1
Xfanout98 net101 net98 VPWR VGND sg13g2_buf_1
XFILLER_23_795 VPWR VGND sg13g2_decap_8
XFILLER_10_467 VPWR VGND sg13g2_decap_8
XFILLER_13_64 VPWR VGND sg13g2_decap_8
XFILLER_6_449 VPWR VGND sg13g2_decap_8
XFILLER_2_666 VPWR VGND sg13g2_decap_8
XFILLER_1_154 VPWR VGND sg13g2_decap_8
XFILLER_49_147 VPWR VGND sg13g2_decap_8
XFILLER_18_512 VPWR VGND sg13g2_decap_8
XFILLER_46_854 VPWR VGND sg13g2_decap_8
XFILLER_33_504 VPWR VGND sg13g2_decap_8
XFILLER_45_364 VPWR VGND sg13g2_decap_8
XFILLER_18_589 VPWR VGND sg13g2_decap_8
XdigitalL.g\[105\].u.buff net87 digitalL.g\[105\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_9_232 VPWR VGND sg13g2_decap_8
XFILLER_41_581 VPWR VGND sg13g2_decap_8
XdigitalH.g\[83\].u.buff net57 digitalH.g\[83\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[12\].u.buff net27 digitalH.g\[12\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_1008 VPWR VGND sg13g2_decap_8
XFILLER_36_364 VPWR VGND sg13g2_decap_8
XFILLER_24_515 VPWR VGND sg13g2_decap_8
XFILLER_32_592 VPWR VGND sg13g2_decap_8
XFILLER_20_732 VPWR VGND sg13g2_decap_8
XFILLER_30_1012 VPWR VGND sg13g2_decap_8
XFILLER_20_798 VPWR VGND sg13g2_decap_8
XdigitalL.g\[35\].u.inv VPWR digitalL.g\[35\].u.OUTN net92 VGND sg13g2_inv_1
XFILLER_28_865 VPWR VGND sg13g2_decap_8
XFILLER_15_526 VPWR VGND sg13g2_decap_8
XFILLER_43_824 VPWR VGND sg13g2_fill_2
XFILLER_42_301 VPWR VGND sg13g2_decap_8
XFILLER_27_364 VPWR VGND sg13g2_decap_8
XFILLER_42_378 VPWR VGND sg13g2_decap_8
XFILLER_30_529 VPWR VGND sg13g2_decap_8
XFILLER_24_74 VPWR VGND sg13g2_decap_8
XFILLER_23_592 VPWR VGND sg13g2_decap_8
XFILLER_10_264 VPWR VGND sg13g2_decap_8
XFILLER_7_736 VPWR VGND sg13g2_decap_8
XFILLER_6_246 VPWR VGND sg13g2_decap_8
XFILLER_40_84 VPWR VGND sg13g2_decap_8
XFILLER_3_953 VPWR VGND sg13g2_decap_8
XFILLER_2_463 VPWR VGND sg13g2_decap_8
X_21_ net115 net7 VPWR VGND sg13g2_buf_1
XFILLER_1_56 VPWR VGND sg13g2_decap_8
XFILLER_19_832 VPWR VGND sg13g2_fill_1
XFILLER_46_651 VPWR VGND sg13g2_decap_8
XFILLER_45_161 VPWR VGND sg13g2_decap_8
XFILLER_33_301 VPWR VGND sg13g2_decap_8
XFILLER_18_386 VPWR VGND sg13g2_decap_8
XFILLER_33_378 VPWR VGND sg13g2_decap_8
XFILLER_21_529 VPWR VGND sg13g2_decap_8
XFILLER_46_0 VPWR VGND sg13g2_decap_8
XFILLER_37_651 VPWR VGND sg13g2_decap_8
XFILLER_25_802 VPWR VGND sg13g2_decap_8
XFILLER_36_161 VPWR VGND sg13g2_decap_8
XFILLER_24_312 VPWR VGND sg13g2_decap_8
XFILLER_25_879 VPWR VGND sg13g2_decap_8
XFILLER_12_529 VPWR VGND sg13g2_decap_8
XFILLER_24_389 VPWR VGND sg13g2_decap_8
XFILLER_10_54 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[0\].u.inv VPWR digitalenL.g\[0\].u.OUTN net3 VGND sg13g2_inv_1
XFILLER_0_945 VPWR VGND sg13g2_decap_8
XFILLER_19_30 VPWR VGND sg13g2_decap_8
XFILLER_48_938 VPWR VGND sg13g2_decap_8
XFILLER_19_128 VPWR VGND sg13g2_decap_8
XFILLER_47_448 VPWR VGND sg13g2_decap_8
XdigitalH.g\[81\].u.inv VPWR digitalH.g\[81\].u.OUTN net58 VGND sg13g2_inv_1
XFILLER_28_662 VPWR VGND sg13g2_decap_8
XFILLER_27_161 VPWR VGND sg13g2_decap_8
XFILLER_15_323 VPWR VGND sg13g2_decap_8
XFILLER_43_665 VPWR VGND sg13g2_decap_8
XFILLER_35_84 VPWR VGND sg13g2_decap_8
XFILLER_42_175 VPWR VGND sg13g2_decap_8
XFILLER_30_326 VPWR VGND sg13g2_decap_8
XFILLER_11_540 VPWR VGND sg13g2_decap_8
XFILLER_7_533 VPWR VGND sg13g2_decap_8
XFILLER_3_750 VPWR VGND sg13g2_decap_8
XFILLER_2_260 VPWR VGND sg13g2_decap_8
XdigitalL.g\[120\].u.buff net77 digitalL.g\[120\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_448 VPWR VGND sg13g2_decap_8
XFILLER_25_109 VPWR VGND sg13g2_decap_8
XFILLER_18_183 VPWR VGND sg13g2_decap_8
XFILLER_19_695 VPWR VGND sg13g2_decap_8
XFILLER_34_665 VPWR VGND sg13g2_decap_8
XFILLER_22_816 VPWR VGND sg13g2_decap_8
XFILLER_33_175 VPWR VGND sg13g2_decap_8
XFILLER_21_326 VPWR VGND sg13g2_decap_8
XFILLER_30_860 VPWR VGND sg13g2_decap_4
XFILLER_5_1016 VPWR VGND sg13g2_decap_8
XFILLER_5_1027 VPWR VGND sg13g2_fill_2
XFILLER_29_459 VPWR VGND sg13g2_decap_8
XFILLER_40_602 VPWR VGND sg13g2_decap_8
XFILLER_25_676 VPWR VGND sg13g2_decap_8
XFILLER_12_326 VPWR VGND sg13g2_decap_8
XFILLER_24_186 VPWR VGND sg13g2_decap_8
XFILLER_40_679 VPWR VGND sg13g2_decap_8
XFILLER_21_53 VPWR VGND sg13g2_decap_8
XFILLER_4_547 VPWR VGND sg13g2_decap_8
XdigitalH.g\[28\].u.inv VPWR digitalH.g\[28\].u.OUTN net30 VGND sg13g2_inv_1
XdigitalL.g\[46\].u.buff net95 digitalL.g\[46\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_0_742 VPWR VGND sg13g2_decap_8
XFILLER_48_735 VPWR VGND sg13g2_decap_8
XFILLER_47_245 VPWR VGND sg13g2_decap_8
XFILLER_16_610 VPWR VGND sg13g2_decap_8
XFILLER_44_941 VPWR VGND sg13g2_decap_8
XFILLER_15_120 VPWR VGND sg13g2_decap_8
XFILLER_43_462 VPWR VGND sg13g2_decap_8
XFILLER_16_687 VPWR VGND sg13g2_decap_8
XFILLER_31_613 VPWR VGND sg13g2_decap_8
XFILLER_15_197 VPWR VGND sg13g2_decap_8
XFILLER_30_123 VPWR VGND sg13g2_decap_8
XFILLER_7_22 VPWR VGND sg13g2_decap_8
XFILLER_7_330 VPWR VGND sg13g2_decap_8
XFILLER_7_99 VPWR VGND sg13g2_decap_8
XFILLER_39_735 VPWR VGND sg13g2_decap_4
XFILLER_38_245 VPWR VGND sg13g2_decap_8
XFILLER_19_492 VPWR VGND sg13g2_decap_8
XFILLER_34_462 VPWR VGND sg13g2_decap_8
XFILLER_22_613 VPWR VGND sg13g2_decap_8
XFILLER_21_123 VPWR VGND sg13g2_decap_8
XFILLER_30_690 VPWR VGND sg13g2_decap_8
XFILLER_1_539 VPWR VGND sg13g2_decap_8
XFILLER_17_407 VPWR VGND sg13g2_decap_8
XFILLER_29_256 VPWR VGND sg13g2_decap_8
XFILLER_45_749 VPWR VGND sg13g2_decap_8
XFILLER_44_259 VPWR VGND sg13g2_decap_8
XFILLER_26_963 VPWR VGND sg13g2_decap_8
XFILLER_13_624 VPWR VGND sg13g2_decap_8
XFILLER_16_64 VPWR VGND sg13g2_decap_8
XFILLER_25_473 VPWR VGND sg13g2_decap_8
XFILLER_12_123 VPWR VGND sg13g2_decap_8
XFILLER_9_617 VPWR VGND sg13g2_decap_8
XFILLER_8_127 VPWR VGND sg13g2_decap_8
XFILLER_40_476 VPWR VGND sg13g2_decap_8
XFILLER_32_74 VPWR VGND sg13g2_decap_8
XFILLER_21_690 VPWR VGND sg13g2_decap_8
XFILLER_5_834 VPWR VGND sg13g2_decap_8
XFILLER_4_344 VPWR VGND sg13g2_decap_8
XdigitalH.g\[37\].u.buff net44 digitalH.g\[37\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_532 VPWR VGND sg13g2_decap_8
XdigitalL.g\[83\].u.inv VPWR digitalL.g\[83\].u.OUTN net99 VGND sg13g2_inv_1
XFILLER_35_259 VPWR VGND sg13g2_decap_8
XFILLER_16_484 VPWR VGND sg13g2_decap_8
XFILLER_31_410 VPWR VGND sg13g2_decap_8
XFILLER_31_487 VPWR VGND sg13g2_decap_8
XFILLER_12_690 VPWR VGND sg13g2_decap_8
XFILLER_8_694 VPWR VGND sg13g2_decap_8
XFILLER_39_532 VPWR VGND sg13g2_decap_8
XFILLER_27_749 VPWR VGND sg13g2_decap_8
XFILLER_23_900 VPWR VGND sg13g2_decap_8
XFILLER_22_410 VPWR VGND sg13g2_decap_8
XFILLER_23_977 VPWR VGND sg13g2_decap_8
XFILLER_10_649 VPWR VGND sg13g2_decap_8
XFILLER_22_487 VPWR VGND sg13g2_decap_8
XFILLER_2_848 VPWR VGND sg13g2_decap_8
XFILLER_1_336 VPWR VGND sg13g2_decap_8
XFILLER_49_329 VPWR VGND sg13g2_decap_8
XFILLER_17_204 VPWR VGND sg13g2_decap_8
XFILLER_45_546 VPWR VGND sg13g2_decap_8
XFILLER_27_63 VPWR VGND sg13g2_decap_8
XFILLER_32_207 VPWR VGND sg13g2_decap_8
XFILLER_26_760 VPWR VGND sg13g2_decap_8
XFILLER_13_421 VPWR VGND sg13g2_decap_8
XFILLER_25_270 VPWR VGND sg13g2_decap_8
XFILLER_9_414 VPWR VGND sg13g2_decap_8
XFILLER_13_498 VPWR VGND sg13g2_decap_8
XFILLER_43_84 VPWR VGND sg13g2_decap_8
XFILLER_40_273 VPWR VGND sg13g2_decap_8
XFILLER_5_631 VPWR VGND sg13g2_decap_8
XdigitalL.g\[61\].u.buff net105 digitalL.g\[61\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_141 VPWR VGND sg13g2_decap_8
XFILLER_4_78 VPWR VGND sg13g2_decap_8
XFILLER_49_896 VPWR VGND sg13g2_decap_8
XFILLER_36_546 VPWR VGND sg13g2_decap_8
XFILLER_23_207 VPWR VGND sg13g2_decap_8
XFILLER_16_281 VPWR VGND sg13g2_decap_8
XFILLER_20_925 VPWR VGND sg13g2_decap_8
XFILLER_31_284 VPWR VGND sg13g2_decap_8
XFILLER_8_491 VPWR VGND sg13g2_decap_8
XFILLER_15_708 VPWR VGND sg13g2_decap_8
XFILLER_27_546 VPWR VGND sg13g2_decap_8
XFILLER_14_218 VPWR VGND sg13g2_decap_8
Xfanout22 net23 net22 VPWR VGND sg13g2_buf_1
Xfanout33 net35 net33 VPWR VGND sg13g2_buf_1
Xfanout44 net46 net44 VPWR VGND sg13g2_buf_1
Xfanout55 net59 net55 VPWR VGND sg13g2_buf_1
XFILLER_23_774 VPWR VGND sg13g2_decap_8
Xfanout66 net67 net66 VPWR VGND sg13g2_buf_1
Xfanout77 net80 net77 VPWR VGND sg13g2_buf_1
Xfanout88 net90 net88 VPWR VGND sg13g2_buf_1
Xfanout99 net101 net99 VPWR VGND sg13g2_buf_1
XFILLER_22_284 VPWR VGND sg13g2_decap_8
XFILLER_10_446 VPWR VGND sg13g2_decap_8
XFILLER_13_43 VPWR VGND sg13g2_decap_8
XdigitalL.g\[31\].u.inv VPWR digitalL.g\[31\].u.OUTN net84 VGND sg13g2_inv_1
XFILLER_6_428 VPWR VGND sg13g2_decap_8
XFILLER_2_645 VPWR VGND sg13g2_decap_8
XFILLER_1_133 VPWR VGND sg13g2_decap_8
XFILLER_49_126 VPWR VGND sg13g2_decap_8
XFILLER_46_833 VPWR VGND sg13g2_decap_8
XFILLER_38_84 VPWR VGND sg13g2_decap_8
XFILLER_45_343 VPWR VGND sg13g2_decap_8
XFILLER_18_568 VPWR VGND sg13g2_decap_8
XFILLER_41_560 VPWR VGND sg13g2_decap_8
XFILLER_9_211 VPWR VGND sg13g2_decap_8
XFILLER_13_295 VPWR VGND sg13g2_decap_8
XdigitalL.g\[126\].u.inv VPWR digitalL.g\[126\].u.OUTN net69 VGND sg13g2_inv_1
XFILLER_9_288 VPWR VGND sg13g2_decap_8
XdigitalH.g\[76\].u.inv VPWR digitalH.g\[76\].u.OUTN net60 VGND sg13g2_inv_1
XdigitalH.g\[52\].u.buff net50 digitalH.g\[52\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_49_693 VPWR VGND sg13g2_decap_8
XFILLER_36_343 VPWR VGND sg13g2_decap_8
XFILLER_32_571 VPWR VGND sg13g2_decap_8
XFILLER_20_711 VPWR VGND sg13g2_decap_8
XFILLER_20_777 VPWR VGND sg13g2_decap_8
XFILLER_28_844 VPWR VGND sg13g2_decap_8
XFILLER_27_343 VPWR VGND sg13g2_decap_8
XFILLER_15_505 VPWR VGND sg13g2_decap_8
XFILLER_42_357 VPWR VGND sg13g2_decap_8
XFILLER_30_508 VPWR VGND sg13g2_decap_8
XFILLER_11_722 VPWR VGND sg13g2_decap_8
XFILLER_24_53 VPWR VGND sg13g2_decap_8
XFILLER_23_571 VPWR VGND sg13g2_decap_8
XFILLER_10_243 VPWR VGND sg13g2_decap_8
XFILLER_7_715 VPWR VGND sg13g2_decap_8
XFILLER_6_225 VPWR VGND sg13g2_decap_8
XFILLER_40_63 VPWR VGND sg13g2_decap_8
XFILLER_3_932 VPWR VGND sg13g2_decap_8
XFILLER_2_442 VPWR VGND sg13g2_decap_8
X_20_ net115 net6 VPWR VGND sg13g2_buf_1
XFILLER_1_35 VPWR VGND sg13g2_decap_8
XFILLER_46_630 VPWR VGND sg13g2_decap_8
XFILLER_45_140 VPWR VGND sg13g2_decap_8
XFILLER_18_365 VPWR VGND sg13g2_decap_8
XFILLER_33_357 VPWR VGND sg13g2_decap_8
XFILLER_21_508 VPWR VGND sg13g2_decap_8
XFILLER_14_582 VPWR VGND sg13g2_decap_8
XdigitalH.g\[0\].u.buff net21 digitalH.g\[0\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_0 VPWR VGND sg13g2_decap_8
Xinput1 ui_in[0] net1 VPWR VGND sg13g2_buf_1
XFILLER_49_490 VPWR VGND sg13g2_decap_8
XFILLER_37_630 VPWR VGND sg13g2_decap_8
XFILLER_36_140 VPWR VGND sg13g2_decap_8
XFILLER_25_858 VPWR VGND sg13g2_decap_8
XFILLER_12_508 VPWR VGND sg13g2_decap_8
XFILLER_24_368 VPWR VGND sg13g2_decap_8
XFILLER_20_585 VPWR VGND sg13g2_decap_8
XFILLER_4_729 VPWR VGND sg13g2_decap_8
XFILLER_10_33 VPWR VGND sg13g2_decap_8
XFILLER_3_239 VPWR VGND sg13g2_decap_8
XFILLER_0_924 VPWR VGND sg13g2_decap_8
XFILLER_48_917 VPWR VGND sg13g2_decap_8
XFILLER_47_427 VPWR VGND sg13g2_decap_8
XFILLER_19_107 VPWR VGND sg13g2_decap_8
XFILLER_28_641 VPWR VGND sg13g2_decap_8
XFILLER_19_86 VPWR VGND sg13g2_decap_8
XFILLER_15_302 VPWR VGND sg13g2_decap_8
XdigitalH.g\[24\].u.inv VPWR digitalH.g\[24\].u.OUTN net29 VGND sg13g2_inv_1
XFILLER_27_140 VPWR VGND sg13g2_decap_8
XFILLER_43_644 VPWR VGND sg13g2_decap_8
XFILLER_42_154 VPWR VGND sg13g2_decap_8
XFILLER_35_63 VPWR VGND sg13g2_decap_8
XFILLER_31_806 VPWR VGND sg13g2_fill_1
XFILLER_15_379 VPWR VGND sg13g2_decap_8
XFILLER_30_305 VPWR VGND sg13g2_decap_8
XFILLER_7_512 VPWR VGND sg13g2_decap_8
XFILLER_11_596 VPWR VGND sg13g2_decap_8
XFILLER_7_589 VPWR VGND sg13g2_decap_8
XFILLER_38_427 VPWR VGND sg13g2_decap_8
XFILLER_47_994 VPWR VGND sg13g2_decap_8
XFILLER_19_674 VPWR VGND sg13g2_decap_8
XFILLER_18_162 VPWR VGND sg13g2_decap_8
XFILLER_34_644 VPWR VGND sg13g2_decap_8
XFILLER_33_154 VPWR VGND sg13g2_decap_8
XFILLER_21_305 VPWR VGND sg13g2_decap_8
XdigitalL.g\[78\].u.inv VPWR digitalL.g\[78\].u.OUTN net107 VGND sg13g2_inv_1
XFILLER_29_438 VPWR VGND sg13g2_decap_8
XFILLER_25_655 VPWR VGND sg13g2_decap_8
XFILLER_12_305 VPWR VGND sg13g2_decap_8
XFILLER_24_165 VPWR VGND sg13g2_decap_8
XFILLER_8_309 VPWR VGND sg13g2_decap_8
XFILLER_40_658 VPWR VGND sg13g2_decap_8
XFILLER_21_883 VPWR VGND sg13g2_decap_8
XFILLER_20_382 VPWR VGND sg13g2_decap_8
XFILLER_21_32 VPWR VGND sg13g2_decap_8
XFILLER_4_526 VPWR VGND sg13g2_decap_8
XFILLER_0_721 VPWR VGND sg13g2_decap_8
XFILLER_0_798 VPWR VGND sg13g2_decap_8
XFILLER_48_714 VPWR VGND sg13g2_decap_8
XdigitalL.g\[86\].u.buff net99 digitalL.g\[86\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_224 VPWR VGND sg13g2_decap_8
XdigitalL.g\[15\].u.buff net74 digitalL.g\[15\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_84 VPWR VGND sg13g2_decap_8
XFILLER_44_920 VPWR VGND sg13g2_decap_8
XFILLER_16_666 VPWR VGND sg13g2_decap_8
XFILLER_43_441 VPWR VGND sg13g2_decap_8
XFILLER_15_176 VPWR VGND sg13g2_decap_8
XdigitalH.g\[7\].u.inv VPWR digitalH.g\[7\].u.OUTN net24 VGND sg13g2_inv_1
XFILLER_44_997 VPWR VGND sg13g2_decap_8
XFILLER_30_102 VPWR VGND sg13g2_decap_8
XFILLER_31_669 VPWR VGND sg13g2_decap_8
XFILLER_8_821 VPWR VGND sg13g2_fill_2
XFILLER_30_179 VPWR VGND sg13g2_decap_8
XFILLER_11_393 VPWR VGND sg13g2_decap_8
XdigitalH.g\[109\].u.buff net39 digitalH.g\[109\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_7_78 VPWR VGND sg13g2_decap_8
XFILLER_8_876 VPWR VGND sg13g2_fill_1
XFILLER_7_386 VPWR VGND sg13g2_decap_8
XFILLER_30_4 VPWR VGND sg13g2_decap_8
XFILLER_39_714 VPWR VGND sg13g2_decap_8
XFILLER_38_224 VPWR VGND sg13g2_decap_8
XFILLER_47_791 VPWR VGND sg13g2_decap_8
XFILLER_19_471 VPWR VGND sg13g2_decap_8
XFILLER_34_441 VPWR VGND sg13g2_decap_8
XFILLER_21_102 VPWR VGND sg13g2_decap_8
XFILLER_22_669 VPWR VGND sg13g2_decap_8
XFILLER_21_179 VPWR VGND sg13g2_decap_8
XFILLER_1_518 VPWR VGND sg13g2_decap_8
XFILLER_29_235 VPWR VGND sg13g2_decap_8
XFILLER_45_728 VPWR VGND sg13g2_decap_8
XFILLER_44_238 VPWR VGND sg13g2_decap_8
XFILLER_26_942 VPWR VGND sg13g2_decap_8
XFILLER_16_43 VPWR VGND sg13g2_decap_8
XFILLER_25_452 VPWR VGND sg13g2_decap_8
XFILLER_12_102 VPWR VGND sg13g2_decap_8
XFILLER_13_603 VPWR VGND sg13g2_decap_8
XFILLER_8_106 VPWR VGND sg13g2_decap_8
XFILLER_40_455 VPWR VGND sg13g2_decap_8
XFILLER_12_179 VPWR VGND sg13g2_decap_8
XFILLER_32_53 VPWR VGND sg13g2_decap_8
XFILLER_5_813 VPWR VGND sg13g2_decap_8
XFILLER_4_323 VPWR VGND sg13g2_decap_8
XFILLER_48_511 VPWR VGND sg13g2_decap_8
XFILLER_0_595 VPWR VGND sg13g2_decap_8
XdigitalL.g\[26\].u.inv VPWR digitalL.g\[26\].u.OUTN net83 VGND sg13g2_inv_1
XFILLER_48_588 VPWR VGND sg13g2_decap_8
XFILLER_36_728 VPWR VGND sg13g2_decap_8
XdigitalH.g\[77\].u.buff net60 digitalH.g\[77\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_35_238 VPWR VGND sg13g2_decap_8
XFILLER_16_463 VPWR VGND sg13g2_decap_8
XFILLER_31_466 VPWR VGND sg13g2_decap_8
XFILLER_11_190 VPWR VGND sg13g2_decap_8
XFILLER_8_673 VPWR VGND sg13g2_decap_8
XFILLER_7_183 VPWR VGND sg13g2_decap_8
XFILLER_4_890 VPWR VGND sg13g2_decap_8
XFILLER_39_511 VPWR VGND sg13g2_decap_8
XFILLER_2_1009 VPWR VGND sg13g2_decap_8
XFILLER_39_588 VPWR VGND sg13g2_decap_8
XFILLER_27_728 VPWR VGND sg13g2_decap_8
XFILLER_26_249 VPWR VGND sg13g2_decap_8
XFILLER_23_956 VPWR VGND sg13g2_decap_8
XFILLER_22_466 VPWR VGND sg13g2_decap_8
XFILLER_10_628 VPWR VGND sg13g2_decap_8
XFILLER_2_827 VPWR VGND sg13g2_decap_8
XFILLER_1_315 VPWR VGND sg13g2_decap_8
XFILLER_49_308 VPWR VGND sg13g2_decap_8
XFILLER_45_525 VPWR VGND sg13g2_decap_8
XFILLER_27_42 VPWR VGND sg13g2_decap_8
XFILLER_13_400 VPWR VGND sg13g2_decap_8
XFILLER_13_477 VPWR VGND sg13g2_decap_8
XFILLER_43_63 VPWR VGND sg13g2_decap_8
XFILLER_40_252 VPWR VGND sg13g2_decap_8
XFILLER_5_610 VPWR VGND sg13g2_decap_8
XFILLER_4_120 VPWR VGND sg13g2_decap_8
XFILLER_5_687 VPWR VGND sg13g2_decap_8
XFILLER_4_197 VPWR VGND sg13g2_decap_8
XFILLER_4_57 VPWR VGND sg13g2_decap_8
XdigitalL.g\[30\].u.buff net84 digitalL.g\[30\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[122\].u.inv VPWR digitalL.g\[122\].u.OUTN net77 VGND sg13g2_inv_1
XFILLER_1_882 VPWR VGND sg13g2_decap_8
XFILLER_0_392 VPWR VGND sg13g2_decap_8
XFILLER_49_875 VPWR VGND sg13g2_decap_8
XFILLER_48_385 VPWR VGND sg13g2_decap_8
XFILLER_36_525 VPWR VGND sg13g2_decap_8
XFILLER_16_260 VPWR VGND sg13g2_decap_8
XdigitalH.g\[72\].u.inv VPWR digitalH.g\[72\].u.OUTN net61 VGND sg13g2_inv_1
XdigitalH.g\[124\].u.buff net21 digitalH.g\[124\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_904 VPWR VGND sg13g2_fill_1
XFILLER_31_263 VPWR VGND sg13g2_decap_8
XFILLER_8_470 VPWR VGND sg13g2_decap_8
XFILLER_39_385 VPWR VGND sg13g2_decap_8
XFILLER_27_525 VPWR VGND sg13g2_decap_8
XFILLER_42_539 VPWR VGND sg13g2_decap_8
Xfanout34 net35 net34 VPWR VGND sg13g2_buf_1
Xfanout45 net46 net45 VPWR VGND sg13g2_buf_1
Xfanout56 net59 net56 VPWR VGND sg13g2_buf_1
Xfanout23 net2 net23 VPWR VGND sg13g2_buf_1
XFILLER_23_753 VPWR VGND sg13g2_decap_8
XFILLER_10_425 VPWR VGND sg13g2_decap_8
XFILLER_13_22 VPWR VGND sg13g2_decap_8
Xfanout67 net2 net67 VPWR VGND sg13g2_buf_1
Xfanout78 net80 net78 VPWR VGND sg13g2_buf_1
Xfanout89 net90 net89 VPWR VGND sg13g2_buf_1
XFILLER_22_263 VPWR VGND sg13g2_decap_8
XFILLER_6_407 VPWR VGND sg13g2_decap_8
XFILLER_7_919 VPWR VGND sg13g2_fill_1
XFILLER_13_99 VPWR VGND sg13g2_decap_8
XFILLER_2_624 VPWR VGND sg13g2_decap_8
XFILLER_1_112 VPWR VGND sg13g2_decap_8
XFILLER_49_105 VPWR VGND sg13g2_decap_8
XFILLER_1_189 VPWR VGND sg13g2_decap_8
XFILLER_38_63 VPWR VGND sg13g2_decap_8
XFILLER_46_812 VPWR VGND sg13g2_decap_8
XFILLER_45_322 VPWR VGND sg13g2_decap_8
XFILLER_18_547 VPWR VGND sg13g2_decap_8
XFILLER_46_889 VPWR VGND sg13g2_decap_8
XFILLER_45_399 VPWR VGND sg13g2_decap_8
XFILLER_33_539 VPWR VGND sg13g2_decap_8
XFILLER_13_274 VPWR VGND sg13g2_decap_8
XFILLER_9_267 VPWR VGND sg13g2_decap_8
XFILLER_6_963 VPWR VGND sg13g2_decap_8
XdigitalH.g\[19\].u.inv VPWR digitalH.g\[19\].u.OUTN net28 VGND sg13g2_inv_1
XFILLER_5_484 VPWR VGND sg13g2_decap_8
XdigitalL.g\[114\].u.buff net78 digitalL.g\[114\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[92\].u.buff net55 digitalH.g\[92\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_49_672 VPWR VGND sg13g2_decap_8
XdigitalH.g\[21\].u.buff net29 digitalH.g\[21\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_182 VPWR VGND sg13g2_decap_8
XFILLER_36_322 VPWR VGND sg13g2_decap_8
XFILLER_36_399 VPWR VGND sg13g2_decap_8
XFILLER_32_550 VPWR VGND sg13g2_decap_8
XFILLER_47_609 VPWR VGND sg13g2_decap_8
XFILLER_46_119 VPWR VGND sg13g2_decap_8
XFILLER_28_823 VPWR VGND sg13g2_decap_8
XFILLER_39_182 VPWR VGND sg13g2_decap_8
XFILLER_27_322 VPWR VGND sg13g2_decap_8
XFILLER_43_826 VPWR VGND sg13g2_fill_1
XFILLER_42_336 VPWR VGND sg13g2_decap_8
XFILLER_27_399 VPWR VGND sg13g2_decap_8
XFILLER_24_32 VPWR VGND sg13g2_decap_8
XFILLER_23_550 VPWR VGND sg13g2_decap_8
XFILLER_11_701 VPWR VGND sg13g2_decap_8
XFILLER_10_222 VPWR VGND sg13g2_decap_8
XFILLER_6_204 VPWR VGND sg13g2_decap_8
XFILLER_10_299 VPWR VGND sg13g2_decap_8
XFILLER_40_42 VPWR VGND sg13g2_decap_8
XdigitalH.g\[20\].u.inv VPWR digitalH.g\[20\].u.OUTN net28 VGND sg13g2_inv_1
XdigitalL.g\[5\].u.buff net71 digitalL.g\[5\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_911 VPWR VGND sg13g2_decap_8
XFILLER_2_421 VPWR VGND sg13g2_decap_8
XFILLER_3_988 VPWR VGND sg13g2_decap_8
XFILLER_2_498 VPWR VGND sg13g2_decap_8
XFILLER_49_84 VPWR VGND sg13g2_decap_8
XFILLER_38_609 VPWR VGND sg13g2_decap_8
XFILLER_1_14 VPWR VGND sg13g2_decap_8
XFILLER_37_119 VPWR VGND sg13g2_decap_8
XFILLER_18_344 VPWR VGND sg13g2_decap_8
XFILLER_46_686 VPWR VGND sg13g2_decap_8
XFILLER_45_196 VPWR VGND sg13g2_decap_8
XFILLER_33_336 VPWR VGND sg13g2_decap_8
XFILLER_14_561 VPWR VGND sg13g2_decap_8
XFILLER_6_771 VPWR VGND sg13g2_fill_2
XFILLER_5_281 VPWR VGND sg13g2_decap_8
Xinput2 ui_in[1] net2 VPWR VGND sg13g2_buf_1
XdigitalL.g\[74\].u.inv VPWR digitalL.g\[74\].u.OUTN net108 VGND sg13g2_inv_1
XFILLER_37_686 VPWR VGND sg13g2_decap_8
XFILLER_36_196 VPWR VGND sg13g2_decap_8
XFILLER_25_837 VPWR VGND sg13g2_decap_8
XFILLER_24_347 VPWR VGND sg13g2_decap_8
XFILLER_20_564 VPWR VGND sg13g2_decap_8
XFILLER_4_708 VPWR VGND sg13g2_decap_8
XFILLER_10_12 VPWR VGND sg13g2_decap_8
XFILLER_3_218 VPWR VGND sg13g2_decap_8
XFILLER_0_903 VPWR VGND sg13g2_decap_8
XFILLER_10_89 VPWR VGND sg13g2_decap_8
XFILLER_47_406 VPWR VGND sg13g2_decap_8
XFILLER_19_65 VPWR VGND sg13g2_decap_8
XFILLER_28_620 VPWR VGND sg13g2_decap_8
XFILLER_43_623 VPWR VGND sg13g2_decap_8
XFILLER_35_42 VPWR VGND sg13g2_decap_8
XFILLER_28_697 VPWR VGND sg13g2_decap_8
XFILLER_15_358 VPWR VGND sg13g2_decap_8
XFILLER_42_133 VPWR VGND sg13g2_decap_8
XFILLER_27_196 VPWR VGND sg13g2_decap_8
XFILLER_11_575 VPWR VGND sg13g2_decap_8
XFILLER_7_568 VPWR VGND sg13g2_decap_8
XdigitalH.g\[3\].u.inv VPWR digitalH.g\[3\].u.OUTN net21 VGND sg13g2_inv_1
XFILLER_3_785 VPWR VGND sg13g2_decap_8
XFILLER_2_295 VPWR VGND sg13g2_decap_8
XFILLER_38_406 VPWR VGND sg13g2_decap_8
XFILLER_18_141 VPWR VGND sg13g2_decap_8
XFILLER_47_973 VPWR VGND sg13g2_decap_8
XFILLER_20_1024 VPWR VGND sg13g2_decap_4
XFILLER_19_653 VPWR VGND sg13g2_decap_8
XFILLER_46_483 VPWR VGND sg13g2_decap_8
XFILLER_34_623 VPWR VGND sg13g2_decap_8
XFILLER_33_133 VPWR VGND sg13g2_decap_8
XFILLER_30_895 VPWR VGND sg13g2_decap_8
XFILLER_29_417 VPWR VGND sg13g2_decap_8
XFILLER_37_483 VPWR VGND sg13g2_decap_8
XFILLER_25_634 VPWR VGND sg13g2_decap_8
XFILLER_24_144 VPWR VGND sg13g2_decap_8
XFILLER_40_637 VPWR VGND sg13g2_decap_8
XFILLER_21_862 VPWR VGND sg13g2_decap_8
XFILLER_21_11 VPWR VGND sg13g2_decap_8
XFILLER_20_361 VPWR VGND sg13g2_decap_8
XFILLER_4_505 VPWR VGND sg13g2_decap_8
XFILLER_21_88 VPWR VGND sg13g2_decap_8
XFILLER_0_700 VPWR VGND sg13g2_decap_8
XFILLER_0_777 VPWR VGND sg13g2_decap_8
XFILLER_47_203 VPWR VGND sg13g2_decap_8
XFILLER_29_984 VPWR VGND sg13g2_decap_8
XFILLER_46_63 VPWR VGND sg13g2_decap_8
XFILLER_28_494 VPWR VGND sg13g2_decap_8
XFILLER_16_645 VPWR VGND sg13g2_decap_8
XFILLER_44_976 VPWR VGND sg13g2_decap_8
XFILLER_43_420 VPWR VGND sg13g2_decap_8
XFILLER_15_155 VPWR VGND sg13g2_decap_8
XdigitalL.g\[55\].u.buff net103 digitalL.g\[55\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_497 VPWR VGND sg13g2_decap_8
XFILLER_31_648 VPWR VGND sg13g2_decap_8
XFILLER_30_158 VPWR VGND sg13g2_decap_8
XFILLER_11_372 VPWR VGND sg13g2_decap_8
XdigitalL.g\[22\].u.inv VPWR digitalL.g\[22\].u.OUTN net82 VGND sg13g2_inv_1
XFILLER_7_365 VPWR VGND sg13g2_decap_8
XFILLER_7_57 VPWR VGND sg13g2_decap_8
XFILLER_3_582 VPWR VGND sg13g2_decap_8
XFILLER_38_203 VPWR VGND sg13g2_decap_8
XFILLER_23_4 VPWR VGND sg13g2_decap_8
XFILLER_19_450 VPWR VGND sg13g2_decap_8
XFILLER_47_770 VPWR VGND sg13g2_decap_8
XFILLER_46_280 VPWR VGND sg13g2_decap_8
XFILLER_34_420 VPWR VGND sg13g2_decap_8
XFILLER_34_497 VPWR VGND sg13g2_decap_8
XFILLER_22_648 VPWR VGND sg13g2_decap_8
XFILLER_21_158 VPWR VGND sg13g2_decap_8
XdigitalL.g\[117\].u.inv VPWR digitalL.g\[117\].u.OUTN net77 VGND sg13g2_inv_1
XdigitalH.g\[67\].u.inv VPWR digitalH.g\[67\].u.OUTN net63 VGND sg13g2_inv_1
XFILLER_27_1008 VPWR VGND sg13g2_decap_8
XFILLER_29_214 VPWR VGND sg13g2_decap_8
XFILLER_45_707 VPWR VGND sg13g2_decap_8
XFILLER_44_217 VPWR VGND sg13g2_decap_8
XFILLER_26_921 VPWR VGND sg13g2_decap_8
XFILLER_16_22 VPWR VGND sg13g2_decap_8
XFILLER_37_280 VPWR VGND sg13g2_decap_8
XFILLER_25_431 VPWR VGND sg13g2_decap_8
XFILLER_26_998 VPWR VGND sg13g2_decap_8
XFILLER_13_659 VPWR VGND sg13g2_decap_8
XFILLER_16_99 VPWR VGND sg13g2_decap_8
XFILLER_40_434 VPWR VGND sg13g2_decap_8
XFILLER_12_158 VPWR VGND sg13g2_decap_8
XFILLER_32_32 VPWR VGND sg13g2_decap_8
XFILLER_4_302 VPWR VGND sg13g2_decap_8
XFILLER_5_869 VPWR VGND sg13g2_decap_8
XFILLER_4_379 VPWR VGND sg13g2_decap_8
XFILLER_0_574 VPWR VGND sg13g2_decap_8
XFILLER_48_567 VPWR VGND sg13g2_decap_8
XFILLER_36_707 VPWR VGND sg13g2_decap_8
XFILLER_35_217 VPWR VGND sg13g2_decap_8
XFILLER_29_781 VPWR VGND sg13g2_decap_8
XFILLER_16_442 VPWR VGND sg13g2_decap_8
XFILLER_28_291 VPWR VGND sg13g2_decap_8
XFILLER_44_784 VPWR VGND sg13g2_decap_8
XFILLER_43_294 VPWR VGND sg13g2_decap_8
XFILLER_32_946 VPWR VGND sg13g2_fill_1
XdigitalH.g\[46\].u.buff net48 digitalH.g\[46\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_31_445 VPWR VGND sg13g2_decap_8
XFILLER_8_652 VPWR VGND sg13g2_decap_8
XFILLER_7_162 VPWR VGND sg13g2_decap_8
XFILLER_39_567 VPWR VGND sg13g2_decap_8
XFILLER_27_707 VPWR VGND sg13g2_decap_8
XFILLER_26_228 VPWR VGND sg13g2_decap_8
XFILLER_34_294 VPWR VGND sg13g2_decap_8
XFILLER_23_935 VPWR VGND sg13g2_decap_8
XFILLER_10_607 VPWR VGND sg13g2_decap_8
XFILLER_22_445 VPWR VGND sg13g2_decap_8
XFILLER_31_990 VPWR VGND sg13g2_fill_1
XFILLER_2_806 VPWR VGND sg13g2_decap_8
XFILLER_45_504 VPWR VGND sg13g2_decap_8
XFILLER_27_21 VPWR VGND sg13g2_decap_8
XFILLER_18_729 VPWR VGND sg13g2_decap_8
XFILLER_17_239 VPWR VGND sg13g2_decap_8
XFILLER_27_98 VPWR VGND sg13g2_decap_8
XFILLER_41_721 VPWR VGND sg13g2_decap_8
XFILLER_26_795 VPWR VGND sg13g2_decap_8
XFILLER_13_456 VPWR VGND sg13g2_decap_8
XFILLER_43_42 VPWR VGND sg13g2_decap_8
XFILLER_40_231 VPWR VGND sg13g2_decap_8
XFILLER_9_449 VPWR VGND sg13g2_decap_8
XFILLER_5_666 VPWR VGND sg13g2_decap_8
XFILLER_4_176 VPWR VGND sg13g2_decap_8
XFILLER_4_36 VPWR VGND sg13g2_decap_8
XFILLER_1_861 VPWR VGND sg13g2_decap_8
XFILLER_0_371 VPWR VGND sg13g2_decap_8
XFILLER_49_854 VPWR VGND sg13g2_decap_8
XdigitalL.g\[70\].u.buff net109 digitalL.g\[70\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_364 VPWR VGND sg13g2_decap_8
XFILLER_36_504 VPWR VGND sg13g2_decap_8
XdigitalH.g\[15\].u.inv VPWR digitalH.g\[15\].u.OUTN net38 VGND sg13g2_inv_1
XFILLER_44_581 VPWR VGND sg13g2_decap_8
XFILLER_32_732 VPWR VGND sg13g2_decap_8
XFILLER_31_242 VPWR VGND sg13g2_decap_8
XFILLER_20_916 VPWR VGND sg13g2_decap_4
XFILLER_39_364 VPWR VGND sg13g2_decap_8
XFILLER_27_504 VPWR VGND sg13g2_decap_8
XFILLER_42_518 VPWR VGND sg13g2_decap_8
XFILLER_35_581 VPWR VGND sg13g2_decap_8
XFILLER_23_732 VPWR VGND sg13g2_decap_8
Xfanout35 net38 net35 VPWR VGND sg13g2_buf_1
Xfanout46 net66 net46 VPWR VGND sg13g2_buf_1
Xfanout24 net25 net24 VPWR VGND sg13g2_buf_1
XFILLER_22_242 VPWR VGND sg13g2_decap_8
XFILLER_10_404 VPWR VGND sg13g2_decap_8
Xfanout57 net59 net57 VPWR VGND sg13g2_buf_1
Xfanout68 net2 net68 VPWR VGND sg13g2_buf_1
Xfanout79 net80 net79 VPWR VGND sg13g2_buf_1
XFILLER_13_78 VPWR VGND sg13g2_decap_8
XdigitalL.g\[69\].u.inv VPWR digitalL.g\[69\].u.OUTN net109 VGND sg13g2_inv_1
XFILLER_2_603 VPWR VGND sg13g2_decap_8
XFILLER_1_168 VPWR VGND sg13g2_decap_8
XFILLER_38_42 VPWR VGND sg13g2_decap_8
XFILLER_45_301 VPWR VGND sg13g2_decap_8
XFILLER_18_526 VPWR VGND sg13g2_decap_8
XFILLER_46_868 VPWR VGND sg13g2_decap_8
XFILLER_45_378 VPWR VGND sg13g2_decap_8
XFILLER_33_518 VPWR VGND sg13g2_decap_8
XFILLER_26_592 VPWR VGND sg13g2_decap_8
XFILLER_13_253 VPWR VGND sg13g2_decap_8
XFILLER_9_246 VPWR VGND sg13g2_decap_8
XFILLER_41_595 VPWR VGND sg13g2_decap_8
XFILLER_6_942 VPWR VGND sg13g2_decap_8
XFILLER_5_463 VPWR VGND sg13g2_decap_8
XFILLER_6_975 VPWR VGND sg13g2_decap_8
XFILLER_6_986 VPWR VGND sg13g2_decap_8
XFILLER_49_651 VPWR VGND sg13g2_decap_8
XFILLER_48_161 VPWR VGND sg13g2_decap_8
XFILLER_36_301 VPWR VGND sg13g2_decap_8
XdigitalH.g\[61\].u.buff net52 digitalH.g\[61\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_378 VPWR VGND sg13g2_decap_8
XFILLER_24_529 VPWR VGND sg13g2_decap_8
XFILLER_20_746 VPWR VGND sg13g2_decap_8
XFILLER_30_1026 VPWR VGND sg13g2_fill_2
XdigitalL.g\[70\].u.inv VPWR digitalL.g\[70\].u.OUTN net111 VGND sg13g2_inv_1
XFILLER_39_161 VPWR VGND sg13g2_decap_8
XFILLER_28_802 VPWR VGND sg13g2_decap_8
XFILLER_27_301 VPWR VGND sg13g2_decap_8
XFILLER_28_879 VPWR VGND sg13g2_decap_8
XFILLER_27_378 VPWR VGND sg13g2_decap_8
XFILLER_42_315 VPWR VGND sg13g2_decap_8
XFILLER_24_11 VPWR VGND sg13g2_decap_8
XFILLER_10_201 VPWR VGND sg13g2_decap_8
XFILLER_24_88 VPWR VGND sg13g2_decap_8
XFILLER_10_278 VPWR VGND sg13g2_decap_8
XFILLER_40_21 VPWR VGND sg13g2_decap_8
XFILLER_40_98 VPWR VGND sg13g2_decap_8
XFILLER_2_400 VPWR VGND sg13g2_decap_8
XFILLER_46_1022 VPWR VGND sg13g2_decap_8
XFILLER_3_967 VPWR VGND sg13g2_decap_8
XFILLER_49_63 VPWR VGND sg13g2_decap_8
XFILLER_2_477 VPWR VGND sg13g2_decap_8
XFILLER_19_846 VPWR VGND sg13g2_decap_8
XFILLER_18_323 VPWR VGND sg13g2_decap_8
XFILLER_46_665 VPWR VGND sg13g2_decap_8
XFILLER_45_175 VPWR VGND sg13g2_decap_8
XFILLER_33_315 VPWR VGND sg13g2_decap_8
XFILLER_14_540 VPWR VGND sg13g2_decap_8
XFILLER_41_392 VPWR VGND sg13g2_decap_8
XFILLER_6_750 VPWR VGND sg13g2_decap_8
XFILLER_5_260 VPWR VGND sg13g2_decap_8
XFILLER_28_109 VPWR VGND sg13g2_decap_8
XdigitalH.g\[126\].u.inv VPWR digitalH.g\[126\].u.OUTN net22 VGND sg13g2_inv_1
Xinput3 ui_in[2] net3 VPWR VGND sg13g2_buf_1
XdigitalL.g\[17\].u.inv VPWR digitalL.g\[17\].u.OUTN net74 VGND sg13g2_inv_1
XFILLER_37_665 VPWR VGND sg13g2_decap_8
XFILLER_25_816 VPWR VGND sg13g2_decap_8
XFILLER_36_175 VPWR VGND sg13g2_decap_8
XFILLER_24_326 VPWR VGND sg13g2_decap_8
XFILLER_18_890 VPWR VGND sg13g2_fill_1
XFILLER_20_543 VPWR VGND sg13g2_decap_8
XFILLER_10_68 VPWR VGND sg13g2_decap_8
XFILLER_0_959 VPWR VGND sg13g2_decap_8
XFILLER_19_44 VPWR VGND sg13g2_decap_8
XFILLER_43_602 VPWR VGND sg13g2_decap_8
XFILLER_28_676 VPWR VGND sg13g2_decap_8
XFILLER_42_112 VPWR VGND sg13g2_decap_8
XFILLER_35_21 VPWR VGND sg13g2_decap_8
XFILLER_27_175 VPWR VGND sg13g2_decap_8
XFILLER_15_337 VPWR VGND sg13g2_decap_8
XFILLER_43_679 VPWR VGND sg13g2_decap_8
XFILLER_35_98 VPWR VGND sg13g2_decap_8
XFILLER_31_819 VPWR VGND sg13g2_fill_1
XFILLER_42_189 VPWR VGND sg13g2_decap_8
XFILLER_24_893 VPWR VGND sg13g2_decap_8
XFILLER_11_554 VPWR VGND sg13g2_decap_8
XFILLER_7_547 VPWR VGND sg13g2_decap_8
XFILLER_3_764 VPWR VGND sg13g2_decap_8
XFILLER_2_274 VPWR VGND sg13g2_decap_8
XFILLER_20_1003 VPWR VGND sg13g2_decap_4
XFILLER_19_632 VPWR VGND sg13g2_decap_8
XFILLER_18_120 VPWR VGND sg13g2_decap_8
XFILLER_47_952 VPWR VGND sg13g2_decap_8
XFILLER_46_462 VPWR VGND sg13g2_decap_8
XFILLER_34_602 VPWR VGND sg13g2_decap_8
XFILLER_18_197 VPWR VGND sg13g2_decap_8
XFILLER_33_112 VPWR VGND sg13g2_decap_8
XFILLER_34_679 VPWR VGND sg13g2_decap_8
XFILLER_33_189 VPWR VGND sg13g2_decap_8
XFILLER_30_885 VPWR VGND sg13g2_decap_4
XFILLER_44_0 VPWR VGND sg13g2_decap_8
XdigitalL.g\[113\].u.inv VPWR digitalL.g\[113\].u.OUTN net78 VGND sg13g2_inv_1
XFILLER_37_462 VPWR VGND sg13g2_decap_8
XFILLER_25_613 VPWR VGND sg13g2_decap_8
XdigitalH.g\[63\].u.inv VPWR digitalH.g\[63\].u.OUTN net53 VGND sg13g2_inv_1
XFILLER_24_123 VPWR VGND sg13g2_decap_8
XFILLER_40_616 VPWR VGND sg13g2_decap_8
XFILLER_21_841 VPWR VGND sg13g2_decap_8
XFILLER_20_340 VPWR VGND sg13g2_decap_8
XFILLER_21_67 VPWR VGND sg13g2_decap_8
XFILLER_0_756 VPWR VGND sg13g2_decap_8
XFILLER_48_749 VPWR VGND sg13g2_decap_8
XFILLER_47_259 VPWR VGND sg13g2_decap_8
XFILLER_46_42 VPWR VGND sg13g2_decap_8
XFILLER_29_963 VPWR VGND sg13g2_decap_8
XFILLER_16_624 VPWR VGND sg13g2_decap_8
XFILLER_28_473 VPWR VGND sg13g2_decap_8
XFILLER_15_134 VPWR VGND sg13g2_decap_8
XFILLER_44_955 VPWR VGND sg13g2_decap_8
XFILLER_43_476 VPWR VGND sg13g2_decap_8
XFILLER_31_627 VPWR VGND sg13g2_decap_8
XFILLER_30_137 VPWR VGND sg13g2_decap_8
XFILLER_24_690 VPWR VGND sg13g2_decap_8
XdigitalL.g\[95\].u.buff net89 digitalL.g\[95\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_11_351 VPWR VGND sg13g2_decap_8
XFILLER_7_36 VPWR VGND sg13g2_decap_8
XFILLER_7_344 VPWR VGND sg13g2_decap_8
XdigitalL.g\[24\].u.buff net82 digitalL.g\[24\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_561 VPWR VGND sg13g2_decap_8
XdigitalH.g\[118\].u.buff net33 digitalH.g\[118\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_259 VPWR VGND sg13g2_decap_8
XFILLER_34_476 VPWR VGND sg13g2_decap_8
XFILLER_22_627 VPWR VGND sg13g2_decap_8
XFILLER_21_137 VPWR VGND sg13g2_decap_8
XFILLER_26_900 VPWR VGND sg13g2_decap_8
XFILLER_25_410 VPWR VGND sg13g2_decap_8
XFILLER_16_78 VPWR VGND sg13g2_decap_8
XFILLER_26_977 VPWR VGND sg13g2_decap_8
XFILLER_13_638 VPWR VGND sg13g2_decap_8
XFILLER_40_413 VPWR VGND sg13g2_decap_8
XFILLER_25_487 VPWR VGND sg13g2_decap_8
XFILLER_12_137 VPWR VGND sg13g2_decap_8
XFILLER_32_11 VPWR VGND sg13g2_decap_8
XFILLER_32_88 VPWR VGND sg13g2_decap_8
XFILLER_5_848 VPWR VGND sg13g2_decap_8
XFILLER_4_358 VPWR VGND sg13g2_decap_8
XFILLER_0_553 VPWR VGND sg13g2_decap_8
XFILLER_48_546 VPWR VGND sg13g2_decap_8
XFILLER_29_760 VPWR VGND sg13g2_decap_8
XFILLER_16_421 VPWR VGND sg13g2_decap_8
XFILLER_28_270 VPWR VGND sg13g2_decap_8
XFILLER_44_763 VPWR VGND sg13g2_decap_8
XFILLER_16_498 VPWR VGND sg13g2_decap_8
XFILLER_43_273 VPWR VGND sg13g2_decap_8
XFILLER_31_424 VPWR VGND sg13g2_decap_8
XdigitalL.g\[108\].u.buff net86 digitalL.g\[108\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_8_631 VPWR VGND sg13g2_decap_8
XFILLER_7_141 VPWR VGND sg13g2_decap_8
XdigitalH.g\[86\].u.buff net57 digitalH.g\[86\].u.OUTP VPWR VGND sg13g2_buf_1
XdacH digitalH.g\[64\].u.OUTP digitalH.g\[64\].u.OUTN digitalH.g\[65\].u.OUTP digitalH.g\[65\].u.OUTN
+ digitalH.g\[66\].u.OUTP digitalH.g\[66\].u.OUTN digitalH.g\[67\].u.OUTP digitalH.g\[67\].u.OUTN
+ digitalH.g\[68\].u.OUTP digitalH.g\[68\].u.OUTN digitalH.g\[69\].u.OUTP digitalH.g\[69\].u.OUTN
+ digitalH.g\[70\].u.OUTP digitalH.g\[70\].u.OUTN digitalH.g\[71\].u.OUTP digitalH.g\[71\].u.OUTN
+ digitalH.g\[72\].u.OUTP digitalH.g\[72\].u.OUTN digitalenH.g\[2\].u.OUTP digitalenH.g\[2\].u.OUTN
+ digitalH.g\[73\].u.OUTP digitalH.g\[73\].u.OUTN digitalH.g\[74\].u.OUTP digitalH.g\[74\].u.OUTN
+ digitalH.g\[75\].u.OUTP digitalH.g\[75\].u.OUTN digitalH.g\[76\].u.OUTP digitalH.g\[76\].u.OUTN
+ digitalH.g\[77\].u.OUTP digitalH.g\[77\].u.OUTN digitalH.g\[78\].u.OUTP digitalH.g\[78\].u.OUTN
+ digitalH.g\[79\].u.OUTP digitalH.g\[79\].u.OUTN digitalH.g\[80\].u.OUTP digitalH.g\[80\].u.OUTN
+ digitalH.g\[81\].u.OUTP digitalH.g\[81\].u.OUTN digitalH.g\[82\].u.OUTP digitalH.g\[82\].u.OUTN
+ digitalH.g\[83\].u.OUTP digitalH.g\[83\].u.OUTN digitalH.g\[84\].u.OUTP digitalH.g\[84\].u.OUTN
+ digitalH.g\[85\].u.OUTP digitalH.g\[85\].u.OUTN digitalH.g\[86\].u.OUTP digitalH.g\[86\].u.OUTN
+ digitalH.g\[87\].u.OUTP digitalH.g\[87\].u.OUTN digitalH.g\[88\].u.OUTP digitalH.g\[88\].u.OUTN
+ digitalH.g\[89\].u.OUTP digitalH.g\[89\].u.OUTN digitalH.g\[90\].u.OUTP digitalH.g\[90\].u.OUTN
+ digitalH.g\[91\].u.OUTP digitalH.g\[91\].u.OUTN digitalH.g\[92\].u.OUTP digitalH.g\[92\].u.OUTN
+ digitalH.g\[93\].u.OUTP digitalH.g\[93\].u.OUTN digitalH.g\[94\].u.OUTP digitalH.g\[94\].u.OUTN
+ digitalH.g\[95\].u.OUTP digitalH.g\[95\].u.OUTN digitalH.g\[96\].u.OUTP digitalH.g\[96\].u.OUTN
+ digitalH.g\[97\].u.OUTP digitalH.g\[97\].u.OUTN digitalH.g\[98\].u.OUTP digitalH.g\[98\].u.OUTN
+ digitalH.g\[99\].u.OUTP digitalH.g\[99\].u.OUTN digitalH.g\[100\].u.OUTP digitalH.g\[100\].u.OUTN
+ digitalH.g\[101\].u.OUTP digitalH.g\[101\].u.OUTN digitalH.g\[102\].u.OUTP digitalH.g\[102\].u.OUTN
+ digitalH.g\[103\].u.OUTP digitalH.g\[103\].u.OUTN digitalH.g\[104\].u.OUTP digitalH.g\[104\].u.OUTN
+ digitalH.g\[105\].u.OUTP digitalH.g\[105\].u.OUTN digitalH.g\[106\].u.OUTP digitalH.g\[106\].u.OUTN
+ digitalH.g\[107\].u.OUTP digitalH.g\[107\].u.OUTN digitalH.g\[108\].u.OUTP digitalH.g\[108\].u.OUTN
+ digitalH.g\[109\].u.OUTP digitalH.g\[109\].u.OUTN digitalH.g\[110\].u.OUTP digitalH.g\[110\].u.OUTN
+ digitalH.g\[111\].u.OUTP digitalH.g\[111\].u.OUTN digitalH.g\[112\].u.OUTP digitalH.g\[112\].u.OUTN
+ digitalH.g\[113\].u.OUTP digitalH.g\[113\].u.OUTN digitalH.g\[114\].u.OUTP digitalH.g\[114\].u.OUTN
+ digitalH.g\[115\].u.OUTP digitalH.g\[115\].u.OUTN digitalH.g\[116\].u.OUTP digitalH.g\[116\].u.OUTN
+ digitalH.g\[117\].u.OUTP digitalH.g\[117\].u.OUTN digitalH.g\[118\].u.OUTP digitalH.g\[118\].u.OUTN
+ digitalH.g\[119\].u.OUTP digitalH.g\[119\].u.OUTN digitalH.g\[120\].u.OUTP digitalH.g\[120\].u.OUTN
+ digitalH.g\[121\].u.OUTP digitalH.g\[121\].u.OUTN digitalH.g\[122\].u.OUTP digitalH.g\[122\].u.OUTN
+ digitalenH.g\[3\].u.OUTP digitalenH.g\[3\].u.OUTN digitalH.g\[123\].u.OUTP digitalH.g\[123\].u.OUTN
+ digitalH.g\[124\].u.OUTP digitalH.g\[124\].u.OUTN digitalH.g\[125\].u.OUTP digitalH.g\[125\].u.OUTN
+ digitalH.g\[126\].u.OUTP digitalH.g\[126\].u.OUTN digitalH.g\[127\].u.OUTP digitalH.g\[127\].u.OUTN
+ digitalH.g\[0\].u.OUTP digitalH.g\[0\].u.OUTN digitalH.g\[1\].u.OUTP digitalH.g\[1\].u.OUTN
+ digitalH.g\[2\].u.OUTP digitalH.g\[2\].u.OUTN digitalH.g\[3\].u.OUTP digitalH.g\[3\].u.OUTN
+ digitalH.g\[4\].u.OUTP digitalH.g\[4\].u.OUTN digitalH.g\[5\].u.OUTP digitalH.g\[5\].u.OUTN
+ digitalH.g\[6\].u.OUTP digitalenH.g\[0\].u.OUTP digitalenH.g\[0\].u.OUTN digitalH.g\[6\].u.OUTN
+ digitalH.g\[7\].u.OUTP digitalH.g\[7\].u.OUTN digitalH.g\[8\].u.OUTP digitalH.g\[8\].u.OUTN
+ digitalH.g\[9\].u.OUTP digitalH.g\[9\].u.OUTN digitalH.g\[10\].u.OUTP digitalH.g\[10\].u.OUTN
+ digitalH.g\[11\].u.OUTP digitalH.g\[11\].u.OUTN digitalH.g\[12\].u.OUTP digitalH.g\[12\].u.OUTN
+ digitalH.g\[13\].u.OUTP digitalH.g\[13\].u.OUTN digitalH.g\[14\].u.OUTP digitalH.g\[14\].u.OUTN
+ digitalH.g\[15\].u.OUTP digitalH.g\[15\].u.OUTN digitalH.g\[16\].u.OUTP digitalH.g\[16\].u.OUTN
+ digitalH.g\[17\].u.OUTP digitalH.g\[17\].u.OUTN digitalH.g\[18\].u.OUTP digitalH.g\[18\].u.OUTN
+ digitalH.g\[19\].u.OUTP digitalH.g\[19\].u.OUTN digitalH.g\[20\].u.OUTP digitalH.g\[20\].u.OUTN
+ digitalH.g\[21\].u.OUTP digitalH.g\[21\].u.OUTN digitalH.g\[22\].u.OUTP digitalH.g\[22\].u.OUTN
+ digitalH.g\[23\].u.OUTP digitalH.g\[23\].u.OUTN digitalH.g\[24\].u.OUTP digitalH.g\[24\].u.OUTN
+ digitalH.g\[25\].u.OUTP digitalH.g\[25\].u.OUTN digitalH.g\[26\].u.OUTP digitalH.g\[26\].u.OUTN
+ digitalH.g\[27\].u.OUTP digitalH.g\[27\].u.OUTN digitalH.g\[28\].u.OUTP digitalH.g\[28\].u.OUTN
+ digitalH.g\[29\].u.OUTP digitalH.g\[29\].u.OUTN digitalH.g\[30\].u.OUTP digitalH.g\[30\].u.OUTN
+ digitalH.g\[31\].u.OUTP digitalH.g\[31\].u.OUTN digitalH.g\[33\].u.OUTP digitalH.g\[33\].u.OUTN
+ digitalH.g\[32\].u.OUTP digitalH.g\[32\].u.OUTN digitalH.g\[34\].u.OUTP digitalH.g\[34\].u.OUTN
+ digitalH.g\[35\].u.OUTP digitalH.g\[35\].u.OUTN digitalH.g\[36\].u.OUTP digitalH.g\[36\].u.OUTN
+ digitalH.g\[37\].u.OUTP digitalH.g\[37\].u.OUTN digitalH.g\[38\].u.OUTP digitalH.g\[38\].u.OUTN
+ digitalH.g\[39\].u.OUTP digitalH.g\[39\].u.OUTN digitalH.g\[40\].u.OUTP digitalH.g\[40\].u.OUTN
+ digitalH.g\[41\].u.OUTP digitalH.g\[41\].u.OUTN digitalH.g\[42\].u.OUTP digitalH.g\[42\].u.OUTN
+ digitalH.g\[43\].u.OUTP digitalH.g\[43\].u.OUTN digitalH.g\[44\].u.OUTP digitalH.g\[44\].u.OUTN
+ digitalH.g\[45\].u.OUTP digitalH.g\[45\].u.OUTN digitalH.g\[46\].u.OUTP digitalH.g\[46\].u.OUTN
+ digitalH.g\[47\].u.OUTP digitalH.g\[47\].u.OUTN digitalH.g\[48\].u.OUTP digitalH.g\[48\].u.OUTN
+ digitalH.g\[49\].u.OUTP digitalH.g\[49\].u.OUTN digitalH.g\[50\].u.OUTP digitalH.g\[50\].u.OUTN
+ digitalH.g\[51\].u.OUTP digitalH.g\[51\].u.OUTN digitalH.g\[52\].u.OUTP digitalH.g\[52\].u.OUTN
+ digitalH.g\[53\].u.OUTP digitalH.g\[53\].u.OUTN digitalH.g\[54\].u.OUTP digitalH.g\[54\].u.OUTN
+ digitalH.g\[55\].u.OUTP digitalH.g\[55\].u.OUTN digitalH.g\[56\].u.OUTP digitalH.g\[56\].u.OUTN
+ digitalH.g\[57\].u.OUTP digitalH.g\[57\].u.OUTN digitalH.g\[58\].u.OUTP digitalH.g\[58\].u.OUTN
+ digitalH.g\[59\].u.OUTP digitalH.g\[59\].u.OUTN digitalH.g\[60\].u.OUTP digitalH.g\[60\].u.OUTN
+ digitalH.g\[61\].u.OUTP digitalH.g\[61\].u.OUTN digitalH.g\[62\].u.OUTP digitalH.g\[62\].u.OUTN
+ digitalH.g\[63\].u.OUTP digitalH.g\[63\].u.OUTN digitalenH.g\[1\].u.OUTP digitalenH.g\[1\].u.OUTN
+ VGND VPWR dac128module
XdigitalH.g\[11\].u.inv VPWR digitalH.g\[11\].u.OUTN net26 VGND sg13g2_inv_1
XdigitalH.g\[15\].u.buff net26 digitalH.g\[15\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_546 VPWR VGND sg13g2_decap_8
XFILLER_26_207 VPWR VGND sg13g2_decap_8
XFILLER_35_730 VPWR VGND sg13g2_fill_2
Xheichips25_pudding_120 VPWR VGND uio_oe[5] sg13g2_tiehi
XFILLER_23_914 VPWR VGND sg13g2_decap_8
XFILLER_34_273 VPWR VGND sg13g2_decap_8
XFILLER_22_424 VPWR VGND sg13g2_decap_8
XFILLER_18_708 VPWR VGND sg13g2_decap_8
XFILLER_17_218 VPWR VGND sg13g2_decap_8
XdigitalL.g\[65\].u.inv VPWR digitalL.g\[65\].u.OUTN net110 VGND sg13g2_inv_1
XFILLER_27_77 VPWR VGND sg13g2_decap_8
XFILLER_41_700 VPWR VGND sg13g2_decap_8
XFILLER_26_774 VPWR VGND sg13g2_decap_8
XFILLER_43_21 VPWR VGND sg13g2_decap_8
XFILLER_41_733 VPWR VGND sg13g2_fill_2
XFILLER_40_210 VPWR VGND sg13g2_decap_8
XFILLER_25_284 VPWR VGND sg13g2_decap_8
XFILLER_13_435 VPWR VGND sg13g2_decap_8
XFILLER_9_428 VPWR VGND sg13g2_decap_8
XFILLER_43_98 VPWR VGND sg13g2_decap_8
XFILLER_40_287 VPWR VGND sg13g2_decap_8
XFILLER_22_991 VPWR VGND sg13g2_decap_8
XFILLER_5_645 VPWR VGND sg13g2_decap_8
XFILLER_4_15 VPWR VGND sg13g2_decap_8
XFILLER_4_155 VPWR VGND sg13g2_decap_8
XFILLER_1_840 VPWR VGND sg13g2_decap_8
XFILLER_0_350 VPWR VGND sg13g2_decap_8
XFILLER_49_833 VPWR VGND sg13g2_decap_8
XFILLER_48_343 VPWR VGND sg13g2_decap_8
XFILLER_1_1022 VPWR VGND sg13g2_decap_8
XFILLER_44_560 VPWR VGND sg13g2_decap_8
XFILLER_32_711 VPWR VGND sg13g2_decap_8
XFILLER_16_295 VPWR VGND sg13g2_decap_8
XFILLER_31_221 VPWR VGND sg13g2_decap_8
XFILLER_20_939 VPWR VGND sg13g2_fill_2
XFILLER_31_298 VPWR VGND sg13g2_decap_8
XFILLER_39_343 VPWR VGND sg13g2_decap_8
XFILLER_35_560 VPWR VGND sg13g2_decap_8
XFILLER_23_711 VPWR VGND sg13g2_decap_8
Xfanout36 net38 net36 VPWR VGND sg13g2_buf_1
Xfanout47 net49 net47 VPWR VGND sg13g2_buf_1
Xfanout25 net32 net25 VPWR VGND sg13g2_buf_1
XFILLER_22_221 VPWR VGND sg13g2_decap_8
Xfanout58 net59 net58 VPWR VGND sg13g2_buf_1
Xfanout69 net70 net69 VPWR VGND sg13g2_buf_1
XFILLER_23_788 VPWR VGND sg13g2_decap_8
XFILLER_13_57 VPWR VGND sg13g2_decap_8
XFILLER_22_298 VPWR VGND sg13g2_decap_8
XFILLER_2_659 VPWR VGND sg13g2_decap_8
XFILLER_1_147 VPWR VGND sg13g2_decap_8
XFILLER_38_21 VPWR VGND sg13g2_decap_8
XFILLER_18_505 VPWR VGND sg13g2_decap_8
XFILLER_46_847 VPWR VGND sg13g2_decap_8
XFILLER_38_98 VPWR VGND sg13g2_decap_8
XFILLER_45_357 VPWR VGND sg13g2_decap_8
XFILLER_14_722 VPWR VGND sg13g2_decap_8
XFILLER_26_571 VPWR VGND sg13g2_decap_8
XFILLER_13_232 VPWR VGND sg13g2_decap_8
XFILLER_9_225 VPWR VGND sg13g2_decap_8
XFILLER_41_574 VPWR VGND sg13g2_decap_8
XdigitalL.g\[6\].u.inv VPWR digitalL.g\[6\].u.OUTN net71 VGND sg13g2_inv_1
XFILLER_5_442 VPWR VGND sg13g2_decap_8
XFILLER_48_7 VPWR VGND sg13g2_decap_8
XFILLER_49_630 VPWR VGND sg13g2_decap_8
XFILLER_23_1012 VPWR VGND sg13g2_decap_8
XFILLER_48_140 VPWR VGND sg13g2_decap_8
XdigitalL.g\[123\].u.buff net76 digitalL.g\[123\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_357 VPWR VGND sg13g2_decap_8
XFILLER_24_508 VPWR VGND sg13g2_decap_8
XFILLER_17_582 VPWR VGND sg13g2_decap_8
XFILLER_32_585 VPWR VGND sg13g2_decap_8
XFILLER_20_725 VPWR VGND sg13g2_decap_8
XdigitalH.g\[30\].u.buff net31 digitalH.g\[30\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[122\].u.inv VPWR digitalH.g\[122\].u.OUTN net33 VGND sg13g2_inv_1
XFILLER_30_1005 VPWR VGND sg13g2_decap_8
XdigitalL.g\[13\].u.inv VPWR digitalL.g\[13\].u.OUTN net73 VGND sg13g2_inv_1
XFILLER_39_140 VPWR VGND sg13g2_decap_8
XFILLER_28_858 VPWR VGND sg13g2_decap_8
XFILLER_27_357 VPWR VGND sg13g2_decap_8
XFILLER_15_519 VPWR VGND sg13g2_decap_8
XFILLER_24_67 VPWR VGND sg13g2_decap_8
XFILLER_11_736 VPWR VGND sg13g2_fill_2
XFILLER_23_585 VPWR VGND sg13g2_decap_8
XFILLER_10_257 VPWR VGND sg13g2_decap_8
XFILLER_7_729 VPWR VGND sg13g2_decap_8
XdigitalL.g\[108\].u.inv VPWR digitalL.g\[108\].u.OUTN net86 VGND sg13g2_inv_1
XFILLER_6_239 VPWR VGND sg13g2_decap_8
XFILLER_40_77 VPWR VGND sg13g2_decap_8
XdigitalH.g\[58\].u.inv VPWR digitalH.g\[58\].u.OUTN net52 VGND sg13g2_inv_1
XFILLER_3_946 VPWR VGND sg13g2_decap_8
XFILLER_46_1001 VPWR VGND sg13g2_decap_8
XFILLER_2_456 VPWR VGND sg13g2_decap_8
XFILLER_49_42 VPWR VGND sg13g2_decap_8
XdigitalL.g\[49\].u.buff net102 digitalL.g\[49\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_644 VPWR VGND sg13g2_decap_8
XFILLER_1_49 VPWR VGND sg13g2_decap_8
XFILLER_18_302 VPWR VGND sg13g2_decap_8
XFILLER_45_154 VPWR VGND sg13g2_decap_8
XFILLER_18_379 VPWR VGND sg13g2_decap_8
XFILLER_14_596 VPWR VGND sg13g2_decap_8
XFILLER_41_371 VPWR VGND sg13g2_decap_8
XFILLER_6_784 VPWR VGND sg13g2_fill_2
Xinput4 ui_in[3] net4 VPWR VGND sg13g2_buf_1
XFILLER_37_644 VPWR VGND sg13g2_decap_8
XFILLER_36_154 VPWR VGND sg13g2_decap_8
XFILLER_24_305 VPWR VGND sg13g2_decap_8
XFILLER_32_382 VPWR VGND sg13g2_decap_8
XFILLER_20_522 VPWR VGND sg13g2_decap_8
XFILLER_20_599 VPWR VGND sg13g2_decap_8
XFILLER_10_47 VPWR VGND sg13g2_decap_8
XFILLER_0_938 VPWR VGND sg13g2_decap_8
XFILLER_19_23 VPWR VGND sg13g2_decap_8
XFILLER_28_655 VPWR VGND sg13g2_decap_8
XFILLER_15_316 VPWR VGND sg13g2_decap_8
XFILLER_27_154 VPWR VGND sg13g2_decap_8
XFILLER_43_658 VPWR VGND sg13g2_decap_8
XFILLER_42_168 VPWR VGND sg13g2_decap_8
XFILLER_35_77 VPWR VGND sg13g2_decap_8
XFILLER_30_319 VPWR VGND sg13g2_decap_8
XFILLER_24_872 VPWR VGND sg13g2_decap_8
XFILLER_11_533 VPWR VGND sg13g2_decap_8
XFILLER_23_382 VPWR VGND sg13g2_decap_8
XFILLER_7_526 VPWR VGND sg13g2_decap_8
XFILLER_3_743 VPWR VGND sg13g2_decap_8
XFILLER_2_253 VPWR VGND sg13g2_decap_8
XFILLER_47_931 VPWR VGND sg13g2_decap_8
XFILLER_19_611 VPWR VGND sg13g2_decap_8
XFILLER_18_8 VPWR VGND sg13g2_decap_8
XFILLER_46_441 VPWR VGND sg13g2_decap_8
XFILLER_18_176 VPWR VGND sg13g2_decap_8
XFILLER_19_688 VPWR VGND sg13g2_decap_8
XFILLER_34_658 VPWR VGND sg13g2_decap_8
XFILLER_22_809 VPWR VGND sg13g2_decap_8
XFILLER_33_168 VPWR VGND sg13g2_decap_8
XFILLER_21_319 VPWR VGND sg13g2_decap_8
XFILLER_14_393 VPWR VGND sg13g2_decap_8
XFILLER_30_864 VPWR VGND sg13g2_fill_2
XFILLER_30_853 VPWR VGND sg13g2_decap_8
XFILLER_37_0 VPWR VGND sg13g2_decap_8
XFILLER_5_1009 VPWR VGND sg13g2_decap_8
XFILLER_37_441 VPWR VGND sg13g2_decap_8
XFILLER_2_92 VPWR VGND sg13g2_decap_8
XFILLER_24_102 VPWR VGND sg13g2_decap_8
XFILLER_25_669 VPWR VGND sg13g2_decap_8
XFILLER_12_319 VPWR VGND sg13g2_decap_8
XFILLER_24_179 VPWR VGND sg13g2_decap_8
XFILLER_21_820 VPWR VGND sg13g2_decap_8
XFILLER_21_46 VPWR VGND sg13g2_decap_8
XFILLER_20_396 VPWR VGND sg13g2_decap_8
XFILLER_0_735 VPWR VGND sg13g2_decap_8
XFILLER_48_728 VPWR VGND sg13g2_decap_8
XFILLER_47_238 VPWR VGND sg13g2_decap_8
XFILLER_46_21 VPWR VGND sg13g2_decap_8
XFILLER_29_942 VPWR VGND sg13g2_decap_8
XFILLER_16_603 VPWR VGND sg13g2_decap_8
XFILLER_44_934 VPWR VGND sg13g2_decap_8
XFILLER_28_452 VPWR VGND sg13g2_decap_8
XFILLER_15_113 VPWR VGND sg13g2_decap_8
XFILLER_46_98 VPWR VGND sg13g2_decap_8
XFILLER_43_455 VPWR VGND sg13g2_decap_8
XFILLER_31_606 VPWR VGND sg13g2_decap_8
XFILLER_30_116 VPWR VGND sg13g2_decap_8
XFILLER_11_330 VPWR VGND sg13g2_decap_8
XFILLER_8_813 VPWR VGND sg13g2_fill_1
XFILLER_7_15 VPWR VGND sg13g2_decap_8
XFILLER_7_323 VPWR VGND sg13g2_decap_8
XdigitalL.g\[64\].u.buff net109 digitalL.g\[64\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_540 VPWR VGND sg13g2_decap_8
XFILLER_39_728 VPWR VGND sg13g2_decap_8
XFILLER_38_238 VPWR VGND sg13g2_decap_8
XFILLER_19_485 VPWR VGND sg13g2_decap_8
XFILLER_34_455 VPWR VGND sg13g2_decap_8
XFILLER_22_606 VPWR VGND sg13g2_decap_8
XFILLER_15_680 VPWR VGND sg13g2_decap_8
XFILLER_21_116 VPWR VGND sg13g2_decap_8
XFILLER_14_190 VPWR VGND sg13g2_decap_8
XFILLER_30_683 VPWR VGND sg13g2_decap_8
XFILLER_7_890 VPWR VGND sg13g2_decap_4
XFILLER_29_249 VPWR VGND sg13g2_decap_8
XFILLER_26_956 VPWR VGND sg13g2_decap_8
XFILLER_13_617 VPWR VGND sg13g2_decap_8
XFILLER_16_57 VPWR VGND sg13g2_decap_8
XFILLER_25_466 VPWR VGND sg13g2_decap_8
XFILLER_12_116 VPWR VGND sg13g2_decap_8
XFILLER_40_469 VPWR VGND sg13g2_decap_8
XFILLER_21_683 VPWR VGND sg13g2_decap_8
XFILLER_32_67 VPWR VGND sg13g2_decap_8
XFILLER_20_193 VPWR VGND sg13g2_decap_8
XFILLER_5_827 VPWR VGND sg13g2_decap_8
XdigitalL.g\[61\].u.inv VPWR digitalL.g\[61\].u.OUTN net105 VGND sg13g2_inv_1
XFILLER_4_337 VPWR VGND sg13g2_decap_8
XFILLER_0_532 VPWR VGND sg13g2_decap_8
XFILLER_48_525 VPWR VGND sg13g2_decap_8
XFILLER_16_400 VPWR VGND sg13g2_decap_8
XFILLER_44_742 VPWR VGND sg13g2_decap_8
XFILLER_43_252 VPWR VGND sg13g2_decap_8
XFILLER_16_477 VPWR VGND sg13g2_decap_8
XFILLER_31_403 VPWR VGND sg13g2_decap_8
XFILLER_8_610 VPWR VGND sg13g2_decap_8
XFILLER_12_683 VPWR VGND sg13g2_decap_8
XFILLER_7_120 VPWR VGND sg13g2_decap_8
XFILLER_8_687 VPWR VGND sg13g2_decap_8
XFILLER_7_197 VPWR VGND sg13g2_decap_8
XdigitalH.g\[55\].u.buff net51 digitalH.g\[55\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_525 VPWR VGND sg13g2_decap_8
XFILLER_19_282 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_121 VPWR VGND uio_oe[6] sg13g2_tiehi
XFILLER_34_252 VPWR VGND sg13g2_decap_8
XFILLER_22_403 VPWR VGND sg13g2_decap_8
XFILLER_30_480 VPWR VGND sg13g2_decap_8
XFILLER_1_329 VPWR VGND sg13g2_decap_8
XdigitalH.g\[117\].u.inv VPWR digitalH.g\[117\].u.OUTN net33 VGND sg13g2_inv_1
XFILLER_45_539 VPWR VGND sg13g2_decap_8
XFILLER_27_56 VPWR VGND sg13g2_decap_8
XFILLER_26_753 VPWR VGND sg13g2_decap_8
XFILLER_13_414 VPWR VGND sg13g2_decap_8
XFILLER_25_263 VPWR VGND sg13g2_decap_8
XFILLER_9_407 VPWR VGND sg13g2_decap_8
XFILLER_43_77 VPWR VGND sg13g2_decap_8
XFILLER_40_266 VPWR VGND sg13g2_decap_8
XFILLER_22_970 VPWR VGND sg13g2_decap_8
XFILLER_21_480 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[2\].u.buff net4 digitalenH.g\[2\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_624 VPWR VGND sg13g2_decap_8
XFILLER_4_134 VPWR VGND sg13g2_decap_8
XFILLER_49_812 VPWR VGND sg13g2_decap_8
XFILLER_1_896 VPWR VGND sg13g2_decap_8
XFILLER_48_322 VPWR VGND sg13g2_decap_8
XFILLER_49_889 VPWR VGND sg13g2_decap_8
XdigitalL.g\[2\].u.inv VPWR digitalL.g\[2\].u.OUTN net70 VGND sg13g2_inv_1
XFILLER_48_399 VPWR VGND sg13g2_decap_8
XFILLER_36_539 VPWR VGND sg13g2_decap_8
XFILLER_1_1001 VPWR VGND sg13g2_decap_8
XFILLER_16_274 VPWR VGND sg13g2_decap_8
XFILLER_31_200 VPWR VGND sg13g2_decap_8
XFILLER_31_277 VPWR VGND sg13g2_decap_8
XFILLER_12_480 VPWR VGND sg13g2_decap_8
XFILLER_8_484 VPWR VGND sg13g2_decap_8
XdigitalH.g\[3\].u.buff net23 digitalH.g\[3\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[102\].u.buff net40 digitalH.g\[102\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_322 VPWR VGND sg13g2_decap_8
XFILLER_39_399 VPWR VGND sg13g2_decap_8
XFILLER_27_539 VPWR VGND sg13g2_decap_8
XFILLER_22_200 VPWR VGND sg13g2_decap_8
Xfanout37 net38 net37 VPWR VGND sg13g2_buf_1
Xfanout26 net27 net26 VPWR VGND sg13g2_buf_1
XFILLER_23_767 VPWR VGND sg13g2_decap_8
Xfanout48 net49 net48 VPWR VGND sg13g2_buf_1
Xfanout59 net66 net59 VPWR VGND sg13g2_buf_1
XFILLER_22_277 VPWR VGND sg13g2_decap_8
XFILLER_10_439 VPWR VGND sg13g2_decap_8
XFILLER_13_36 VPWR VGND sg13g2_decap_8
XFILLER_2_638 VPWR VGND sg13g2_decap_8
XFILLER_1_126 VPWR VGND sg13g2_decap_8
XFILLER_49_119 VPWR VGND sg13g2_decap_8
XdigitalL.g\[104\].u.inv VPWR digitalL.g\[104\].u.OUTN net87 VGND sg13g2_inv_1
XFILLER_46_826 VPWR VGND sg13g2_decap_8
XFILLER_38_77 VPWR VGND sg13g2_decap_8
XFILLER_45_336 VPWR VGND sg13g2_decap_8
XFILLER_26_550 VPWR VGND sg13g2_decap_8
XFILLER_14_701 VPWR VGND sg13g2_decap_8
XdigitalH.g\[54\].u.inv VPWR digitalH.g\[54\].u.OUTN net65 VGND sg13g2_inv_1
XFILLER_13_211 VPWR VGND sg13g2_decap_8
XFILLER_9_204 VPWR VGND sg13g2_decap_8
XFILLER_41_553 VPWR VGND sg13g2_decap_8
XFILLER_13_288 VPWR VGND sg13g2_decap_8
XFILLER_6_922 VPWR VGND sg13g2_fill_2
XFILLER_5_421 VPWR VGND sg13g2_decap_8
XFILLER_5_498 VPWR VGND sg13g2_decap_8
XFILLER_1_693 VPWR VGND sg13g2_decap_8
XFILLER_49_686 VPWR VGND sg13g2_decap_8
XFILLER_36_336 VPWR VGND sg13g2_decap_8
XFILLER_48_196 VPWR VGND sg13g2_decap_8
XFILLER_17_561 VPWR VGND sg13g2_decap_8
XFILLER_32_564 VPWR VGND sg13g2_decap_8
XFILLER_20_704 VPWR VGND sg13g2_decap_8
XFILLER_8_281 VPWR VGND sg13g2_decap_8
XFILLER_30_1028 VPWR VGND sg13g2_fill_1
XdigitalH.g\[70\].u.buff net62 digitalH.g\[70\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_92 VPWR VGND sg13g2_decap_8
XFILLER_8_1018 VPWR VGND sg13g2_fill_1
XFILLER_28_837 VPWR VGND sg13g2_decap_8
XFILLER_39_196 VPWR VGND sg13g2_decap_8
XFILLER_27_336 VPWR VGND sg13g2_decap_8
XFILLER_11_715 VPWR VGND sg13g2_decap_8
XFILLER_24_46 VPWR VGND sg13g2_decap_8
XFILLER_23_564 VPWR VGND sg13g2_decap_8
XFILLER_10_236 VPWR VGND sg13g2_decap_8
XFILLER_7_708 VPWR VGND sg13g2_decap_8
XFILLER_6_218 VPWR VGND sg13g2_decap_8
XFILLER_40_56 VPWR VGND sg13g2_decap_8
XFILLER_3_925 VPWR VGND sg13g2_decap_8
XFILLER_49_21 VPWR VGND sg13g2_decap_8
XFILLER_2_435 VPWR VGND sg13g2_decap_8
XFILLER_49_98 VPWR VGND sg13g2_decap_8
XFILLER_1_28 VPWR VGND sg13g2_decap_8
XFILLER_46_623 VPWR VGND sg13g2_decap_8
XFILLER_19_837 VPWR VGND sg13g2_decap_4
XdigitalL.g\[89\].u.buff net98 digitalL.g\[89\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_133 VPWR VGND sg13g2_decap_8
XFILLER_18_358 VPWR VGND sg13g2_decap_8
XdigitalL.g\[18\].u.buff net74 digitalL.g\[18\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_14_575 VPWR VGND sg13g2_decap_8
XFILLER_41_350 VPWR VGND sg13g2_decap_8
XFILLER_5_295 VPWR VGND sg13g2_decap_8
XFILLER_1_490 VPWR VGND sg13g2_decap_8
XFILLER_49_483 VPWR VGND sg13g2_decap_8
XFILLER_37_623 VPWR VGND sg13g2_decap_8
XFILLER_36_133 VPWR VGND sg13g2_decap_8
XFILLER_32_361 VPWR VGND sg13g2_decap_8
XFILLER_20_501 VPWR VGND sg13g2_decap_8
XFILLER_20_578 VPWR VGND sg13g2_decap_8
XFILLER_10_26 VPWR VGND sg13g2_decap_8
XFILLER_0_917 VPWR VGND sg13g2_decap_8
XFILLER_28_634 VPWR VGND sg13g2_decap_8
XFILLER_19_79 VPWR VGND sg13g2_decap_8
XFILLER_27_133 VPWR VGND sg13g2_decap_8
XFILLER_43_637 VPWR VGND sg13g2_decap_8
XFILLER_35_56 VPWR VGND sg13g2_decap_8
XFILLER_42_147 VPWR VGND sg13g2_decap_8
XFILLER_24_851 VPWR VGND sg13g2_decap_8
XFILLER_11_512 VPWR VGND sg13g2_decap_8
XFILLER_23_361 VPWR VGND sg13g2_decap_8
XFILLER_7_505 VPWR VGND sg13g2_decap_8
XFILLER_11_589 VPWR VGND sg13g2_decap_8
XFILLER_3_722 VPWR VGND sg13g2_decap_8
XFILLER_2_232 VPWR VGND sg13g2_decap_8
XFILLER_3_799 VPWR VGND sg13g2_decap_8
XFILLER_47_910 VPWR VGND sg13g2_decap_8
XFILLER_46_420 VPWR VGND sg13g2_decap_8
XFILLER_19_667 VPWR VGND sg13g2_decap_8
XFILLER_18_155 VPWR VGND sg13g2_decap_8
XdigitalL.g\[56\].u.inv VPWR digitalL.g\[56\].u.OUTN net104 VGND sg13g2_inv_1
XFILLER_47_987 VPWR VGND sg13g2_decap_8
XFILLER_46_497 VPWR VGND sg13g2_decap_8
XFILLER_34_637 VPWR VGND sg13g2_decap_8
XFILLER_33_147 VPWR VGND sg13g2_decap_8
XFILLER_14_372 VPWR VGND sg13g2_decap_8
XFILLER_30_832 VPWR VGND sg13g2_decap_8
XFILLER_6_582 VPWR VGND sg13g2_decap_8
XFILLER_2_71 VPWR VGND sg13g2_decap_8
XFILLER_49_280 VPWR VGND sg13g2_decap_8
XFILLER_37_420 VPWR VGND sg13g2_decap_8
XFILLER_37_497 VPWR VGND sg13g2_decap_8
XFILLER_25_648 VPWR VGND sg13g2_decap_8
XFILLER_24_158 VPWR VGND sg13g2_decap_8
XFILLER_21_876 VPWR VGND sg13g2_decap_8
XFILLER_20_375 VPWR VGND sg13g2_decap_8
XFILLER_21_25 VPWR VGND sg13g2_decap_8
XFILLER_4_519 VPWR VGND sg13g2_decap_8
XFILLER_0_714 VPWR VGND sg13g2_decap_8
XFILLER_48_707 VPWR VGND sg13g2_decap_8
XFILLER_47_217 VPWR VGND sg13g2_decap_8
XFILLER_29_921 VPWR VGND sg13g2_decap_8
XFILLER_28_431 VPWR VGND sg13g2_decap_8
XFILLER_46_77 VPWR VGND sg13g2_decap_8
XFILLER_44_913 VPWR VGND sg13g2_decap_8
XFILLER_29_998 VPWR VGND sg13g2_decap_8
XFILLER_16_659 VPWR VGND sg13g2_decap_8
XFILLER_43_434 VPWR VGND sg13g2_decap_8
XFILLER_15_169 VPWR VGND sg13g2_decap_8
XFILLER_7_302 VPWR VGND sg13g2_decap_8
XFILLER_11_386 VPWR VGND sg13g2_decap_8
XFILLER_7_379 VPWR VGND sg13g2_decap_8
XFILLER_3_596 VPWR VGND sg13g2_decap_8
XFILLER_39_707 VPWR VGND sg13g2_decap_8
XdigitalL.g\[33\].u.buff net84 digitalL.g\[33\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_217 VPWR VGND sg13g2_decap_8
XFILLER_47_784 VPWR VGND sg13g2_decap_8
XFILLER_19_464 VPWR VGND sg13g2_decap_8
XFILLER_46_294 VPWR VGND sg13g2_decap_8
XFILLER_34_434 VPWR VGND sg13g2_decap_8
XdigitalH.g\[127\].u.buff net22 digitalH.g\[127\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_30_662 VPWR VGND sg13g2_decap_8
XFILLER_29_228 VPWR VGND sg13g2_decap_8
XFILLER_37_294 VPWR VGND sg13g2_decap_8
XFILLER_26_935 VPWR VGND sg13g2_decap_8
XFILLER_16_36 VPWR VGND sg13g2_decap_8
XFILLER_25_445 VPWR VGND sg13g2_decap_8
XFILLER_40_448 VPWR VGND sg13g2_decap_8
XFILLER_32_46 VPWR VGND sg13g2_decap_8
XFILLER_21_662 VPWR VGND sg13g2_decap_8
XFILLER_5_806 VPWR VGND sg13g2_decap_8
XFILLER_20_172 VPWR VGND sg13g2_decap_8
XFILLER_4_316 VPWR VGND sg13g2_decap_8
XdigitalH.g\[113\].u.inv VPWR digitalH.g\[113\].u.OUTN net36 VGND sg13g2_inv_1
XFILLER_0_511 VPWR VGND sg13g2_decap_8
XFILLER_0_588 VPWR VGND sg13g2_decap_8
XFILLER_48_504 VPWR VGND sg13g2_decap_8
XFILLER_44_721 VPWR VGND sg13g2_decap_8
XFILLER_29_795 VPWR VGND sg13g2_decap_8
XFILLER_16_456 VPWR VGND sg13g2_decap_8
XFILLER_43_231 VPWR VGND sg13g2_decap_8
XFILLER_44_798 VPWR VGND sg13g2_decap_8
XFILLER_31_459 VPWR VGND sg13g2_decap_8
XFILLER_12_662 VPWR VGND sg13g2_decap_8
XFILLER_11_183 VPWR VGND sg13g2_decap_8
XFILLER_8_666 VPWR VGND sg13g2_decap_8
XFILLER_7_176 VPWR VGND sg13g2_decap_8
XFILLER_4_883 VPWR VGND sg13g2_decap_8
XdigitalH.g\[49\].u.inv VPWR digitalH.g\[49\].u.OUTN net65 VGND sg13g2_inv_1
XdigitalL.g\[117\].u.buff net76 digitalL.g\[117\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_393 VPWR VGND sg13g2_decap_8
XFILLER_39_504 VPWR VGND sg13g2_decap_8
XFILLER_21_4 VPWR VGND sg13g2_decap_8
XdigitalH.g\[95\].u.buff net42 digitalH.g\[95\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[24\].u.buff net29 digitalH.g\[24\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_581 VPWR VGND sg13g2_decap_8
XFILLER_35_721 VPWR VGND sg13g2_fill_1
XFILLER_19_261 VPWR VGND sg13g2_decap_8
XFILLER_34_231 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_122 VPWR VGND uio_oe[7] sg13g2_tiehi
XFILLER_23_949 VPWR VGND sg13g2_decap_8
XFILLER_22_459 VPWR VGND sg13g2_decap_8
XFILLER_8_92 VPWR VGND sg13g2_decap_8
XFILLER_1_308 VPWR VGND sg13g2_decap_8
XFILLER_45_518 VPWR VGND sg13g2_decap_8
XFILLER_27_35 VPWR VGND sg13g2_decap_8
XFILLER_38_581 VPWR VGND sg13g2_decap_8
XFILLER_26_732 VPWR VGND sg13g2_decap_8
XFILLER_25_242 VPWR VGND sg13g2_decap_8
XFILLER_43_56 VPWR VGND sg13g2_decap_8
XFILLER_41_735 VPWR VGND sg13g2_fill_1
XFILLER_40_245 VPWR VGND sg13g2_decap_8
XdigitalL.g\[100\].u.inv VPWR digitalL.g\[100\].u.OUTN net88 VGND sg13g2_inv_1
XFILLER_5_603 VPWR VGND sg13g2_decap_8
XFILLER_4_113 VPWR VGND sg13g2_decap_8
XFILLER_49_1022 VPWR VGND sg13g2_decap_8
XdigitalH.g\[50\].u.inv VPWR digitalH.g\[50\].u.OUTN net50 VGND sg13g2_inv_1
XdigitalL.g\[8\].u.buff net72 digitalL.g\[8\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_48_301 VPWR VGND sg13g2_decap_8
XFILLER_1_875 VPWR VGND sg13g2_decap_8
XFILLER_0_385 VPWR VGND sg13g2_decap_8
XFILLER_49_868 VPWR VGND sg13g2_decap_8
XFILLER_48_378 VPWR VGND sg13g2_decap_8
XFILLER_36_518 VPWR VGND sg13g2_decap_8
XFILLER_29_592 VPWR VGND sg13g2_decap_8
XFILLER_16_253 VPWR VGND sg13g2_decap_8
XFILLER_44_595 VPWR VGND sg13g2_decap_8
XFILLER_32_746 VPWR VGND sg13g2_fill_2
XFILLER_31_256 VPWR VGND sg13g2_decap_8
XFILLER_8_463 VPWR VGND sg13g2_decap_8
XFILLER_4_680 VPWR VGND sg13g2_decap_8
XFILLER_3_190 VPWR VGND sg13g2_decap_8
XFILLER_39_301 VPWR VGND sg13g2_decap_8
XFILLER_27_518 VPWR VGND sg13g2_decap_8
XFILLER_39_378 VPWR VGND sg13g2_decap_8
Xfanout38 net67 net38 VPWR VGND sg13g2_buf_1
Xfanout27 net32 net27 VPWR VGND sg13g2_buf_1
XFILLER_35_595 VPWR VGND sg13g2_decap_8
XFILLER_23_746 VPWR VGND sg13g2_decap_8
XFILLER_13_15 VPWR VGND sg13g2_decap_8
Xfanout49 net66 net49 VPWR VGND sg13g2_buf_1
XFILLER_22_256 VPWR VGND sg13g2_decap_8
XFILLER_10_418 VPWR VGND sg13g2_decap_8
XFILLER_8_8 VPWR VGND sg13g2_decap_8
XFILLER_2_617 VPWR VGND sg13g2_decap_8
XFILLER_1_105 VPWR VGND sg13g2_decap_8
XFILLER_46_805 VPWR VGND sg13g2_decap_8
XFILLER_38_56 VPWR VGND sg13g2_decap_8
XFILLER_45_315 VPWR VGND sg13g2_decap_8
XFILLER_41_532 VPWR VGND sg13g2_decap_8
XFILLER_13_267 VPWR VGND sg13g2_decap_8
XFILLER_6_901 VPWR VGND sg13g2_decap_8
XFILLER_5_400 VPWR VGND sg13g2_decap_8
XFILLER_6_956 VPWR VGND sg13g2_decap_8
XFILLER_5_477 VPWR VGND sg13g2_decap_8
XFILLER_1_672 VPWR VGND sg13g2_decap_8
XFILLER_0_182 VPWR VGND sg13g2_decap_8
XFILLER_49_665 VPWR VGND sg13g2_decap_8
XFILLER_48_175 VPWR VGND sg13g2_decap_8
XFILLER_36_315 VPWR VGND sg13g2_decap_8
XFILLER_17_540 VPWR VGND sg13g2_decap_8
XFILLER_45_882 VPWR VGND sg13g2_decap_8
XFILLER_44_392 VPWR VGND sg13g2_decap_8
XFILLER_32_543 VPWR VGND sg13g2_decap_8
XFILLER_8_260 VPWR VGND sg13g2_decap_8
XFILLER_5_71 VPWR VGND sg13g2_decap_8
XFILLER_28_816 VPWR VGND sg13g2_decap_8
XFILLER_39_175 VPWR VGND sg13g2_decap_8
XFILLER_27_315 VPWR VGND sg13g2_decap_8
XFILLER_43_819 VPWR VGND sg13g2_fill_1
XFILLER_42_329 VPWR VGND sg13g2_decap_8
XFILLER_35_392 VPWR VGND sg13g2_decap_8
XFILLER_24_25 VPWR VGND sg13g2_decap_8
XFILLER_23_543 VPWR VGND sg13g2_decap_8
XFILLER_10_215 VPWR VGND sg13g2_decap_8
XFILLER_11_738 VPWR VGND sg13g2_fill_1
XFILLER_40_35 VPWR VGND sg13g2_decap_8
XFILLER_3_904 VPWR VGND sg13g2_decap_8
XFILLER_2_414 VPWR VGND sg13g2_decap_8
XFILLER_49_77 VPWR VGND sg13g2_decap_8
XFILLER_46_602 VPWR VGND sg13g2_decap_8
XFILLER_45_112 VPWR VGND sg13g2_decap_8
XFILLER_18_337 VPWR VGND sg13g2_decap_8
XFILLER_46_679 VPWR VGND sg13g2_decap_8
XFILLER_27_882 VPWR VGND sg13g2_decap_8
XFILLER_45_189 VPWR VGND sg13g2_decap_8
XFILLER_33_329 VPWR VGND sg13g2_decap_8
XFILLER_14_554 VPWR VGND sg13g2_decap_8
XdigitalL.g\[58\].u.buff net104 digitalL.g\[58\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_6_764 VPWR VGND sg13g2_decap_8
XdigitalL.g\[52\].u.inv VPWR digitalL.g\[52\].u.OUTN net102 VGND sg13g2_inv_1
XFILLER_5_274 VPWR VGND sg13g2_decap_8
XFILLER_2_981 VPWR VGND sg13g2_decap_8
XFILLER_49_462 VPWR VGND sg13g2_decap_8
XFILLER_37_602 VPWR VGND sg13g2_decap_8
XFILLER_36_112 VPWR VGND sg13g2_decap_8
XFILLER_37_679 VPWR VGND sg13g2_decap_8
XFILLER_36_189 VPWR VGND sg13g2_decap_8
XFILLER_18_882 VPWR VGND sg13g2_fill_1
XFILLER_32_340 VPWR VGND sg13g2_decap_8
XFILLER_20_557 VPWR VGND sg13g2_decap_8
XdigitalH.g\[97\].u.inv VPWR digitalH.g\[97\].u.OUTN net42 VGND sg13g2_inv_1
XFILLER_28_613 VPWR VGND sg13g2_decap_8
XFILLER_19_58 VPWR VGND sg13g2_decap_8
XFILLER_27_112 VPWR VGND sg13g2_decap_8
XFILLER_43_616 VPWR VGND sg13g2_decap_8
XFILLER_42_126 VPWR VGND sg13g2_decap_8
XFILLER_35_35 VPWR VGND sg13g2_decap_8
XFILLER_27_189 VPWR VGND sg13g2_decap_8
XFILLER_24_830 VPWR VGND sg13g2_decap_8
XFILLER_23_340 VPWR VGND sg13g2_decap_8
XFILLER_11_568 VPWR VGND sg13g2_decap_8
XFILLER_3_701 VPWR VGND sg13g2_decap_8
XFILLER_2_211 VPWR VGND sg13g2_decap_8
XFILLER_3_778 VPWR VGND sg13g2_decap_8
XFILLER_2_288 VPWR VGND sg13g2_decap_8
XFILLER_18_134 VPWR VGND sg13g2_decap_8
XdigitalH.g\[108\].u.inv VPWR digitalH.g\[108\].u.OUTN net39 VGND sg13g2_inv_1
XFILLER_47_966 VPWR VGND sg13g2_decap_8
XFILLER_20_1028 VPWR VGND sg13g2_fill_1
XFILLER_20_1017 VPWR VGND sg13g2_decap_8
XFILLER_19_646 VPWR VGND sg13g2_decap_8
XFILLER_46_476 VPWR VGND sg13g2_decap_8
XFILLER_34_616 VPWR VGND sg13g2_decap_8
XFILLER_33_126 VPWR VGND sg13g2_decap_8
XFILLER_14_351 VPWR VGND sg13g2_decap_8
XFILLER_30_822 VPWR VGND sg13g2_fill_2
XFILLER_42_693 VPWR VGND sg13g2_decap_8
XFILLER_30_844 VPWR VGND sg13g2_decap_4
XdigitalH.g\[49\].u.buff net50 digitalH.g\[49\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_6_561 VPWR VGND sg13g2_decap_8
XFILLER_2_50 VPWR VGND sg13g2_decap_8
XFILLER_37_476 VPWR VGND sg13g2_decap_8
XFILLER_25_627 VPWR VGND sg13g2_decap_8
XFILLER_24_137 VPWR VGND sg13g2_decap_8
XFILLER_33_693 VPWR VGND sg13g2_decap_8
XFILLER_21_855 VPWR VGND sg13g2_decap_8
XFILLER_21_899 VPWR VGND sg13g2_decap_8
XFILLER_20_354 VPWR VGND sg13g2_decap_8
XFILLER_43_1028 VPWR VGND sg13g2_fill_1
XFILLER_29_900 VPWR VGND sg13g2_decap_8
XFILLER_28_410 VPWR VGND sg13g2_decap_8
XFILLER_46_56 VPWR VGND sg13g2_decap_8
XFILLER_29_977 VPWR VGND sg13g2_decap_8
XFILLER_16_638 VPWR VGND sg13g2_decap_8
XFILLER_43_413 VPWR VGND sg13g2_decap_8
XFILLER_28_487 VPWR VGND sg13g2_decap_8
XFILLER_15_148 VPWR VGND sg13g2_decap_8
XFILLER_44_969 VPWR VGND sg13g2_decap_8
XFILLER_11_365 VPWR VGND sg13g2_decap_8
XFILLER_8_859 VPWR VGND sg13g2_fill_1
XFILLER_7_358 VPWR VGND sg13g2_decap_8
XFILLER_11_92 VPWR VGND sg13g2_decap_8
XFILLER_3_575 VPWR VGND sg13g2_decap_8
XFILLER_47_763 VPWR VGND sg13g2_decap_8
XFILLER_19_443 VPWR VGND sg13g2_decap_8
XdigitalL.g\[73\].u.buff net108 digitalL.g\[73\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_273 VPWR VGND sg13g2_decap_8
XFILLER_34_413 VPWR VGND sg13g2_decap_8
XdigitalH.g\[45\].u.inv VPWR digitalH.g\[45\].u.OUTN net48 VGND sg13g2_inv_1
XFILLER_42_490 VPWR VGND sg13g2_decap_8
XFILLER_30_641 VPWR VGND sg13g2_decap_8
XFILLER_42_0 VPWR VGND sg13g2_decap_8
XFILLER_29_207 VPWR VGND sg13g2_decap_8
XFILLER_26_914 VPWR VGND sg13g2_decap_8
XFILLER_16_15 VPWR VGND sg13g2_decap_8
XFILLER_37_273 VPWR VGND sg13g2_decap_8
XFILLER_25_424 VPWR VGND sg13g2_decap_8
XFILLER_40_427 VPWR VGND sg13g2_decap_8
XFILLER_33_490 VPWR VGND sg13g2_decap_8
XFILLER_32_25 VPWR VGND sg13g2_decap_8
XFILLER_21_641 VPWR VGND sg13g2_decap_8
XFILLER_20_151 VPWR VGND sg13g2_decap_8
XdigitalL.g\[99\].u.inv VPWR digitalL.g\[99\].u.OUTN net88 VGND sg13g2_inv_1
XFILLER_0_567 VPWR VGND sg13g2_decap_8
XFILLER_44_700 VPWR VGND sg13g2_decap_8
XFILLER_29_774 VPWR VGND sg13g2_decap_8
XFILLER_43_210 VPWR VGND sg13g2_decap_8
XFILLER_28_284 VPWR VGND sg13g2_decap_8
XFILLER_16_435 VPWR VGND sg13g2_decap_8
XFILLER_44_777 VPWR VGND sg13g2_decap_8
XFILLER_43_287 VPWR VGND sg13g2_decap_8
XFILLER_31_438 VPWR VGND sg13g2_decap_8
XFILLER_25_991 VPWR VGND sg13g2_decap_8
XFILLER_12_641 VPWR VGND sg13g2_decap_8
XFILLER_11_162 VPWR VGND sg13g2_decap_8
XFILLER_8_645 VPWR VGND sg13g2_decap_8
XFILLER_7_155 VPWR VGND sg13g2_decap_8
XFILLER_4_862 VPWR VGND sg13g2_decap_8
XFILLER_3_372 VPWR VGND sg13g2_decap_8
XFILLER_26_1012 VPWR VGND sg13g2_decap_8
XFILLER_19_240 VPWR VGND sg13g2_decap_8
XFILLER_47_560 VPWR VGND sg13g2_decap_8
XFILLER_35_700 VPWR VGND sg13g2_decap_8
XFILLER_34_210 VPWR VGND sg13g2_decap_8
XdigitalH.g\[64\].u.buff net63 digitalH.g\[64\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_23_928 VPWR VGND sg13g2_decap_8
XFILLER_34_287 VPWR VGND sg13g2_decap_8
XFILLER_22_438 VPWR VGND sg13g2_decap_8
XFILLER_8_71 VPWR VGND sg13g2_decap_8
XFILLER_27_14 VPWR VGND sg13g2_decap_8
XFILLER_38_560 VPWR VGND sg13g2_decap_8
XFILLER_26_711 VPWR VGND sg13g2_decap_8
XFILLER_25_221 VPWR VGND sg13g2_decap_8
XFILLER_41_714 VPWR VGND sg13g2_decap_8
XFILLER_26_788 VPWR VGND sg13g2_decap_8
XFILLER_13_449 VPWR VGND sg13g2_decap_8
XFILLER_43_35 VPWR VGND sg13g2_decap_8
XFILLER_40_224 VPWR VGND sg13g2_decap_8
XFILLER_25_298 VPWR VGND sg13g2_decap_8
XFILLER_5_659 VPWR VGND sg13g2_decap_8
XFILLER_49_1001 VPWR VGND sg13g2_decap_8
XFILLER_4_169 VPWR VGND sg13g2_decap_8
XFILLER_4_29 VPWR VGND sg13g2_decap_8
XFILLER_1_854 VPWR VGND sg13g2_decap_8
XFILLER_0_364 VPWR VGND sg13g2_decap_8
XFILLER_49_847 VPWR VGND sg13g2_decap_8
XFILLER_48_357 VPWR VGND sg13g2_decap_8
XFILLER_29_571 VPWR VGND sg13g2_decap_8
XFILLER_16_232 VPWR VGND sg13g2_decap_8
XFILLER_44_574 VPWR VGND sg13g2_decap_8
XFILLER_32_725 VPWR VGND sg13g2_decap_8
XFILLER_31_235 VPWR VGND sg13g2_decap_8
XFILLER_20_909 VPWR VGND sg13g2_decap_8
XFILLER_8_442 VPWR VGND sg13g2_decap_8
XFILLER_39_357 VPWR VGND sg13g2_decap_8
XdigitalL.g\[47\].u.inv VPWR digitalL.g\[47\].u.OUTN net95 VGND sg13g2_inv_1
XFILLER_35_574 VPWR VGND sg13g2_decap_8
Xfanout28 net29 net28 VPWR VGND sg13g2_buf_1
XFILLER_23_725 VPWR VGND sg13g2_decap_8
Xfanout39 net43 net39 VPWR VGND sg13g2_buf_1
XFILLER_22_235 VPWR VGND sg13g2_decap_8
XdigitalH.g\[111\].u.buff net37 digitalH.g\[111\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_35 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[0\].u.inv VPWR digitalenH.g\[0\].u.OUTN net4 VGND sg13g2_inv_1
XFILLER_18_519 VPWR VGND sg13g2_decap_8
XFILLER_14_736 VPWR VGND sg13g2_fill_2
XFILLER_41_511 VPWR VGND sg13g2_decap_8
XFILLER_26_585 VPWR VGND sg13g2_decap_8
XFILLER_13_246 VPWR VGND sg13g2_decap_8
XFILLER_9_239 VPWR VGND sg13g2_decap_8
XFILLER_41_588 VPWR VGND sg13g2_decap_8
XFILLER_6_935 VPWR VGND sg13g2_decap_8
XFILLER_5_456 VPWR VGND sg13g2_decap_8
XFILLER_1_651 VPWR VGND sg13g2_decap_8
XFILLER_0_161 VPWR VGND sg13g2_decap_8
XFILLER_49_644 VPWR VGND sg13g2_decap_8
XFILLER_23_1026 VPWR VGND sg13g2_fill_2
XFILLER_48_154 VPWR VGND sg13g2_decap_8
XFILLER_45_861 VPWR VGND sg13g2_decap_8
XFILLER_17_596 VPWR VGND sg13g2_decap_8
XFILLER_44_371 VPWR VGND sg13g2_decap_8
XFILLER_32_522 VPWR VGND sg13g2_decap_8
XFILLER_32_599 VPWR VGND sg13g2_decap_8
XFILLER_20_739 VPWR VGND sg13g2_decap_8
XFILLER_30_1019 VPWR VGND sg13g2_decap_8
XFILLER_5_50 VPWR VGND sg13g2_decap_8
XdigitalL.g\[101\].u.buff net88 digitalL.g\[101\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_154 VPWR VGND sg13g2_decap_8
XFILLER_42_308 VPWR VGND sg13g2_decap_8
XFILLER_35_371 VPWR VGND sg13g2_decap_8
XFILLER_23_522 VPWR VGND sg13g2_decap_8
XdigitalH.g\[93\].u.inv VPWR digitalH.g\[93\].u.OUTN net55 VGND sg13g2_inv_1
XFILLER_23_599 VPWR VGND sg13g2_decap_8
XFILLER_40_14 VPWR VGND sg13g2_decap_8
XFILLER_46_1015 VPWR VGND sg13g2_decap_8
XFILLER_49_56 VPWR VGND sg13g2_decap_8
XFILLER_18_316 VPWR VGND sg13g2_decap_8
XFILLER_46_658 VPWR VGND sg13g2_decap_8
XFILLER_45_168 VPWR VGND sg13g2_decap_8
XFILLER_33_308 VPWR VGND sg13g2_decap_8
XFILLER_27_861 VPWR VGND sg13g2_decap_8
XFILLER_26_382 VPWR VGND sg13g2_decap_8
XFILLER_14_533 VPWR VGND sg13g2_decap_8
XFILLER_42_875 VPWR VGND sg13g2_fill_1
XFILLER_41_385 VPWR VGND sg13g2_decap_8
XFILLER_14_92 VPWR VGND sg13g2_decap_8
XdigitalL.g\[98\].u.buff net88 digitalL.g\[98\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_6_743 VPWR VGND sg13g2_decap_8
XdigitalH.g\[104\].u.inv VPWR digitalH.g\[104\].u.OUTN net40 VGND sg13g2_inv_1
XdigitalL.g\[27\].u.buff net83 digitalL.g\[27\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_253 VPWR VGND sg13g2_decap_8
XFILLER_6_798 VPWR VGND sg13g2_decap_8
XFILLER_46_7 VPWR VGND sg13g2_decap_8
XFILLER_2_960 VPWR VGND sg13g2_decap_8
XFILLER_49_441 VPWR VGND sg13g2_decap_8
XFILLER_37_658 VPWR VGND sg13g2_decap_8
XFILLER_36_168 VPWR VGND sg13g2_decap_8
XFILLER_25_809 VPWR VGND sg13g2_decap_8
XFILLER_18_861 VPWR VGND sg13g2_fill_1
XFILLER_24_319 VPWR VGND sg13g2_decap_8
XFILLER_18_894 VPWR VGND sg13g2_fill_1
XFILLER_17_393 VPWR VGND sg13g2_decap_8
XFILLER_32_396 VPWR VGND sg13g2_decap_8
XFILLER_20_536 VPWR VGND sg13g2_decap_8
XFILLER_19_37 VPWR VGND sg13g2_decap_8
XFILLER_35_14 VPWR VGND sg13g2_decap_8
XFILLER_28_669 VPWR VGND sg13g2_decap_8
XFILLER_27_168 VPWR VGND sg13g2_decap_8
XFILLER_42_105 VPWR VGND sg13g2_decap_8
XFILLER_24_886 VPWR VGND sg13g2_decap_8
XFILLER_11_547 VPWR VGND sg13g2_decap_8
XFILLER_23_396 VPWR VGND sg13g2_decap_8
XFILLER_3_757 VPWR VGND sg13g2_decap_8
XFILLER_2_267 VPWR VGND sg13g2_decap_8
XFILLER_18_113 VPWR VGND sg13g2_decap_8
XFILLER_47_945 VPWR VGND sg13g2_decap_8
XFILLER_19_625 VPWR VGND sg13g2_decap_8
XFILLER_46_455 VPWR VGND sg13g2_decap_8
XFILLER_33_105 VPWR VGND sg13g2_decap_8
XFILLER_14_330 VPWR VGND sg13g2_decap_8
XFILLER_42_672 VPWR VGND sg13g2_decap_8
XFILLER_41_182 VPWR VGND sg13g2_decap_8
XFILLER_30_889 VPWR VGND sg13g2_fill_2
XFILLER_30_878 VPWR VGND sg13g2_decap_8
XFILLER_6_540 VPWR VGND sg13g2_decap_8
XdigitalH.g\[89\].u.buff net56 digitalH.g\[89\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[18\].u.buff net27 digitalH.g\[18\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[41\].u.inv VPWR digitalH.g\[41\].u.OUTN net47 VGND sg13g2_inv_1
XFILLER_37_455 VPWR VGND sg13g2_decap_8
XFILLER_25_606 VPWR VGND sg13g2_decap_8
XFILLER_24_116 VPWR VGND sg13g2_decap_8
XFILLER_18_680 VPWR VGND sg13g2_decap_8
XFILLER_17_190 VPWR VGND sg13g2_decap_8
XFILLER_40_609 VPWR VGND sg13g2_decap_8
XFILLER_33_672 VPWR VGND sg13g2_decap_8
XFILLER_32_193 VPWR VGND sg13g2_decap_8
XFILLER_21_834 VPWR VGND sg13g2_decap_8
XFILLER_20_333 VPWR VGND sg13g2_decap_8
XFILLER_0_749 VPWR VGND sg13g2_decap_8
XFILLER_29_956 VPWR VGND sg13g2_decap_8
XFILLER_46_35 VPWR VGND sg13g2_decap_8
XFILLER_28_466 VPWR VGND sg13g2_decap_8
XFILLER_16_617 VPWR VGND sg13g2_decap_8
XdigitalL.g\[95\].u.inv VPWR digitalL.g\[95\].u.OUTN net89 VGND sg13g2_inv_1
XFILLER_44_948 VPWR VGND sg13g2_decap_8
XFILLER_15_127 VPWR VGND sg13g2_decap_8
XFILLER_43_469 VPWR VGND sg13g2_decap_8
XFILLER_24_683 VPWR VGND sg13g2_decap_8
XFILLER_11_344 VPWR VGND sg13g2_decap_8
XFILLER_23_193 VPWR VGND sg13g2_decap_8
XFILLER_7_29 VPWR VGND sg13g2_decap_8
XFILLER_7_337 VPWR VGND sg13g2_decap_8
XFILLER_11_71 VPWR VGND sg13g2_decap_8
XFILLER_3_554 VPWR VGND sg13g2_decap_8
XFILLER_16_8 VPWR VGND sg13g2_decap_8
XFILLER_4_1023 VPWR VGND sg13g2_decap_4
XFILLER_19_422 VPWR VGND sg13g2_decap_8
XFILLER_47_742 VPWR VGND sg13g2_decap_8
XFILLER_46_252 VPWR VGND sg13g2_decap_8
XFILLER_19_499 VPWR VGND sg13g2_decap_8
XFILLER_34_469 VPWR VGND sg13g2_decap_8
XFILLER_15_694 VPWR VGND sg13g2_decap_8
XdigitalL.g\[42\].u.buff net94 digitalL.g\[42\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_30_620 VPWR VGND sg13g2_decap_8
XFILLER_30_697 VPWR VGND sg13g2_decap_8
XFILLER_35_0 VPWR VGND sg13g2_decap_8
XFILLER_37_252 VPWR VGND sg13g2_decap_8
XFILLER_25_403 VPWR VGND sg13g2_decap_8
XFILLER_40_406 VPWR VGND sg13g2_decap_8
XFILLER_21_620 VPWR VGND sg13g2_decap_8
XFILLER_20_130 VPWR VGND sg13g2_decap_8
XFILLER_21_697 VPWR VGND sg13g2_decap_8
XFILLER_0_546 VPWR VGND sg13g2_decap_8
XFILLER_48_539 VPWR VGND sg13g2_decap_8
XFILLER_29_753 VPWR VGND sg13g2_decap_8
XFILLER_16_414 VPWR VGND sg13g2_decap_8
XFILLER_28_263 VPWR VGND sg13g2_decap_8
XFILLER_44_756 VPWR VGND sg13g2_decap_8
XFILLER_43_266 VPWR VGND sg13g2_decap_8
XFILLER_32_918 VPWR VGND sg13g2_fill_2
XFILLER_31_417 VPWR VGND sg13g2_decap_8
XFILLER_25_970 VPWR VGND sg13g2_decap_8
XFILLER_19_1020 VPWR VGND sg13g2_decap_8
XFILLER_12_620 VPWR VGND sg13g2_decap_8
XFILLER_24_480 VPWR VGND sg13g2_decap_8
XFILLER_11_141 VPWR VGND sg13g2_decap_8
XFILLER_12_697 VPWR VGND sg13g2_decap_8
XFILLER_8_624 VPWR VGND sg13g2_decap_8
XFILLER_7_134 VPWR VGND sg13g2_decap_8
XdacL digitalL.g\[64\].u.OUTP digitalL.g\[64\].u.OUTN digitalL.g\[65\].u.OUTP digitalL.g\[65\].u.OUTN
+ digitalL.g\[66\].u.OUTP digitalL.g\[66\].u.OUTN digitalL.g\[67\].u.OUTP digitalL.g\[67\].u.OUTN
+ digitalL.g\[68\].u.OUTP digitalL.g\[68\].u.OUTN digitalL.g\[69\].u.OUTP digitalL.g\[69\].u.OUTN
+ digitalL.g\[70\].u.OUTP digitalL.g\[70\].u.OUTN digitalL.g\[71\].u.OUTP digitalL.g\[71\].u.OUTN
+ digitalL.g\[72\].u.OUTP digitalL.g\[72\].u.OUTN digitalenL.g\[2\].u.OUTP digitalenL.g\[2\].u.OUTN
+ digitalL.g\[73\].u.OUTP digitalL.g\[73\].u.OUTN digitalL.g\[74\].u.OUTP digitalL.g\[74\].u.OUTN
+ digitalL.g\[75\].u.OUTP digitalL.g\[75\].u.OUTN digitalL.g\[76\].u.OUTP digitalL.g\[76\].u.OUTN
+ digitalL.g\[77\].u.OUTP digitalL.g\[77\].u.OUTN digitalL.g\[78\].u.OUTP digitalL.g\[78\].u.OUTN
+ digitalL.g\[79\].u.OUTP digitalL.g\[79\].u.OUTN digitalL.g\[80\].u.OUTP digitalL.g\[80\].u.OUTN
+ digitalL.g\[81\].u.OUTP digitalL.g\[81\].u.OUTN digitalL.g\[82\].u.OUTP digitalL.g\[82\].u.OUTN
+ digitalL.g\[83\].u.OUTP digitalL.g\[83\].u.OUTN digitalL.g\[84\].u.OUTP digitalL.g\[84\].u.OUTN
+ digitalL.g\[85\].u.OUTP digitalL.g\[85\].u.OUTN digitalL.g\[86\].u.OUTP digitalL.g\[86\].u.OUTN
+ digitalL.g\[87\].u.OUTP digitalL.g\[87\].u.OUTN digitalL.g\[88\].u.OUTP digitalL.g\[88\].u.OUTN
+ digitalL.g\[89\].u.OUTP digitalL.g\[89\].u.OUTN digitalL.g\[90\].u.OUTP digitalL.g\[90\].u.OUTN
+ digitalL.g\[91\].u.OUTP digitalL.g\[91\].u.OUTN digitalL.g\[92\].u.OUTP digitalL.g\[92\].u.OUTN
+ digitalL.g\[93\].u.OUTP digitalL.g\[93\].u.OUTN digitalL.g\[94\].u.OUTP digitalL.g\[94\].u.OUTN
+ digitalL.g\[95\].u.OUTP digitalL.g\[95\].u.OUTN digitalL.g\[96\].u.OUTP digitalL.g\[96\].u.OUTN
+ digitalL.g\[97\].u.OUTP digitalL.g\[97\].u.OUTN digitalL.g\[98\].u.OUTP digitalL.g\[98\].u.OUTN
+ digitalL.g\[99\].u.OUTP digitalL.g\[99\].u.OUTN digitalL.g\[100\].u.OUTP digitalL.g\[100\].u.OUTN
+ digitalL.g\[101\].u.OUTP digitalL.g\[101\].u.OUTN digitalL.g\[102\].u.OUTP digitalL.g\[102\].u.OUTN
+ digitalL.g\[103\].u.OUTP digitalL.g\[103\].u.OUTN digitalL.g\[104\].u.OUTP digitalL.g\[104\].u.OUTN
+ digitalL.g\[105\].u.OUTP digitalL.g\[105\].u.OUTN digitalL.g\[106\].u.OUTP digitalL.g\[106\].u.OUTN
+ digitalL.g\[107\].u.OUTP digitalL.g\[107\].u.OUTN digitalL.g\[108\].u.OUTP digitalL.g\[108\].u.OUTN
+ digitalL.g\[109\].u.OUTP digitalL.g\[109\].u.OUTN digitalL.g\[110\].u.OUTP digitalL.g\[110\].u.OUTN
+ digitalL.g\[111\].u.OUTP digitalL.g\[111\].u.OUTN digitalL.g\[112\].u.OUTP digitalL.g\[112\].u.OUTN
+ digitalL.g\[113\].u.OUTP digitalL.g\[113\].u.OUTN digitalL.g\[114\].u.OUTP digitalL.g\[114\].u.OUTN
+ digitalL.g\[115\].u.OUTP digitalL.g\[115\].u.OUTN digitalL.g\[116\].u.OUTP digitalL.g\[116\].u.OUTN
+ digitalL.g\[117\].u.OUTP digitalL.g\[117\].u.OUTN digitalL.g\[118\].u.OUTP digitalL.g\[118\].u.OUTN
+ digitalL.g\[119\].u.OUTP digitalL.g\[119\].u.OUTN digitalL.g\[120\].u.OUTP digitalL.g\[120\].u.OUTN
+ digitalL.g\[121\].u.OUTP digitalL.g\[121\].u.OUTN digitalL.g\[122\].u.OUTP digitalL.g\[122\].u.OUTN
+ digitalenL.g\[3\].u.OUTP digitalenL.g\[3\].u.OUTN digitalL.g\[123\].u.OUTP digitalL.g\[123\].u.OUTN
+ digitalL.g\[124\].u.OUTP digitalL.g\[124\].u.OUTN digitalL.g\[125\].u.OUTP digitalL.g\[125\].u.OUTN
+ digitalL.g\[126\].u.OUTP digitalL.g\[126\].u.OUTN digitalL.g\[127\].u.OUTP digitalL.g\[127\].u.OUTN
+ digitalL.g\[0\].u.OUTP digitalL.g\[0\].u.OUTN digitalL.g\[1\].u.OUTP digitalL.g\[1\].u.OUTN
+ digitalL.g\[2\].u.OUTP digitalL.g\[2\].u.OUTN digitalL.g\[3\].u.OUTP digitalL.g\[3\].u.OUTN
+ digitalL.g\[4\].u.OUTP digitalL.g\[4\].u.OUTN digitalL.g\[5\].u.OUTP digitalL.g\[5\].u.OUTN
+ digitalL.g\[6\].u.OUTP digitalenL.g\[0\].u.OUTP digitalenL.g\[0\].u.OUTN digitalL.g\[6\].u.OUTN
+ digitalL.g\[7\].u.OUTP digitalL.g\[7\].u.OUTN digitalL.g\[8\].u.OUTP digitalL.g\[8\].u.OUTN
+ digitalL.g\[9\].u.OUTP digitalL.g\[9\].u.OUTN digitalL.g\[10\].u.OUTP digitalL.g\[10\].u.OUTN
+ digitalL.g\[11\].u.OUTP digitalL.g\[11\].u.OUTN digitalL.g\[12\].u.OUTP digitalL.g\[12\].u.OUTN
+ digitalL.g\[13\].u.OUTP digitalL.g\[13\].u.OUTN digitalL.g\[14\].u.OUTP digitalL.g\[14\].u.OUTN
+ digitalL.g\[15\].u.OUTP digitalL.g\[15\].u.OUTN digitalL.g\[16\].u.OUTP digitalL.g\[16\].u.OUTN
+ digitalL.g\[17\].u.OUTP digitalL.g\[17\].u.OUTN digitalL.g\[18\].u.OUTP digitalL.g\[18\].u.OUTN
+ digitalL.g\[19\].u.OUTP digitalL.g\[19\].u.OUTN digitalL.g\[20\].u.OUTP digitalL.g\[20\].u.OUTN
+ digitalL.g\[21\].u.OUTP digitalL.g\[21\].u.OUTN digitalL.g\[22\].u.OUTP digitalL.g\[22\].u.OUTN
+ digitalL.g\[23\].u.OUTP digitalL.g\[23\].u.OUTN digitalL.g\[24\].u.OUTP digitalL.g\[24\].u.OUTN
+ digitalL.g\[25\].u.OUTP digitalL.g\[25\].u.OUTN digitalL.g\[26\].u.OUTP digitalL.g\[26\].u.OUTN
+ digitalL.g\[27\].u.OUTP digitalL.g\[27\].u.OUTN digitalL.g\[28\].u.OUTP digitalL.g\[28\].u.OUTN
+ digitalL.g\[29\].u.OUTP digitalL.g\[29\].u.OUTN digitalL.g\[30\].u.OUTP digitalL.g\[30\].u.OUTN
+ digitalL.g\[31\].u.OUTP digitalL.g\[31\].u.OUTN digitalL.g\[33\].u.OUTP digitalL.g\[33\].u.OUTN
+ digitalL.g\[32\].u.OUTP digitalL.g\[32\].u.OUTN digitalL.g\[34\].u.OUTP digitalL.g\[34\].u.OUTN
+ digitalL.g\[35\].u.OUTP digitalL.g\[35\].u.OUTN digitalL.g\[36\].u.OUTP digitalL.g\[36\].u.OUTN
+ digitalL.g\[37\].u.OUTP digitalL.g\[37\].u.OUTN digitalL.g\[38\].u.OUTP digitalL.g\[38\].u.OUTN
+ digitalL.g\[39\].u.OUTP digitalL.g\[39\].u.OUTN digitalL.g\[40\].u.OUTP digitalL.g\[40\].u.OUTN
+ digitalL.g\[41\].u.OUTP digitalL.g\[41\].u.OUTN digitalL.g\[42\].u.OUTP digitalL.g\[42\].u.OUTN
+ digitalL.g\[43\].u.OUTP digitalL.g\[43\].u.OUTN digitalL.g\[44\].u.OUTP digitalL.g\[44\].u.OUTN
+ digitalL.g\[45\].u.OUTP digitalL.g\[45\].u.OUTN digitalL.g\[46\].u.OUTP digitalL.g\[46\].u.OUTN
+ digitalL.g\[47\].u.OUTP digitalL.g\[47\].u.OUTN digitalL.g\[48\].u.OUTP digitalL.g\[48\].u.OUTN
+ digitalL.g\[49\].u.OUTP digitalL.g\[49\].u.OUTN digitalL.g\[50\].u.OUTP digitalL.g\[50\].u.OUTN
+ digitalL.g\[51\].u.OUTP digitalL.g\[51\].u.OUTN digitalL.g\[52\].u.OUTP digitalL.g\[52\].u.OUTN
+ digitalL.g\[53\].u.OUTP digitalL.g\[53\].u.OUTN digitalL.g\[54\].u.OUTP digitalL.g\[54\].u.OUTN
+ digitalL.g\[55\].u.OUTP digitalL.g\[55\].u.OUTN digitalL.g\[56\].u.OUTP digitalL.g\[56\].u.OUTN
+ digitalL.g\[57\].u.OUTP digitalL.g\[57\].u.OUTN digitalL.g\[58\].u.OUTP digitalL.g\[58\].u.OUTN
+ digitalL.g\[59\].u.OUTP digitalL.g\[59\].u.OUTN digitalL.g\[60\].u.OUTP digitalL.g\[60\].u.OUTN
+ digitalL.g\[61\].u.OUTP digitalL.g\[61\].u.OUTN digitalL.g\[62\].u.OUTP digitalL.g\[62\].u.OUTN
+ digitalL.g\[63\].u.OUTP digitalL.g\[63\].u.OUTN digitalenL.g\[1\].u.OUTP digitalenL.g\[1\].u.OUTN
+ VGND VPWR dac128module
XFILLER_22_81 VPWR VGND sg13g2_decap_8
XFILLER_4_841 VPWR VGND sg13g2_decap_8
XFILLER_3_351 VPWR VGND sg13g2_decap_8
XFILLER_39_539 VPWR VGND sg13g2_decap_8
XFILLER_23_907 VPWR VGND sg13g2_decap_8
XFILLER_19_296 VPWR VGND sg13g2_decap_8
XdigitalL.g\[126\].u.buff net69 digitalL.g\[126\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_34_266 VPWR VGND sg13g2_decap_8
XFILLER_22_417 VPWR VGND sg13g2_decap_8
XFILLER_15_491 VPWR VGND sg13g2_decap_8
XFILLER_8_50 VPWR VGND sg13g2_decap_8
XdigitalH.g\[33\].u.buff net31 digitalH.g\[33\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_30_494 VPWR VGND sg13g2_decap_8
XdigitalL.g\[43\].u.inv VPWR digitalL.g\[43\].u.OUTN net94 VGND sg13g2_inv_1
XFILLER_25_200 VPWR VGND sg13g2_decap_8
XFILLER_43_14 VPWR VGND sg13g2_decap_8
XFILLER_26_767 VPWR VGND sg13g2_decap_8
XFILLER_13_428 VPWR VGND sg13g2_decap_8
XFILLER_40_203 VPWR VGND sg13g2_decap_8
XFILLER_25_277 VPWR VGND sg13g2_decap_8
XFILLER_22_984 VPWR VGND sg13g2_decap_8
XFILLER_21_494 VPWR VGND sg13g2_decap_8
XFILLER_5_638 VPWR VGND sg13g2_decap_8
XFILLER_4_148 VPWR VGND sg13g2_decap_8
XdigitalH.g\[88\].u.inv VPWR digitalH.g\[88\].u.OUTN net56 VGND sg13g2_inv_1
XFILLER_1_833 VPWR VGND sg13g2_decap_8
XFILLER_0_343 VPWR VGND sg13g2_decap_8
XFILLER_49_826 VPWR VGND sg13g2_decap_8
XFILLER_48_336 VPWR VGND sg13g2_decap_8
XFILLER_17_701 VPWR VGND sg13g2_decap_8
XFILLER_29_550 VPWR VGND sg13g2_decap_8
XFILLER_1_1015 VPWR VGND sg13g2_decap_8
XFILLER_16_211 VPWR VGND sg13g2_decap_8
XFILLER_17_92 VPWR VGND sg13g2_decap_8
XFILLER_44_553 VPWR VGND sg13g2_decap_8
XFILLER_32_704 VPWR VGND sg13g2_decap_8
XFILLER_16_288 VPWR VGND sg13g2_decap_8
XFILLER_31_214 VPWR VGND sg13g2_decap_8
XFILLER_8_421 VPWR VGND sg13g2_decap_8
XFILLER_12_494 VPWR VGND sg13g2_decap_8
XFILLER_33_91 VPWR VGND sg13g2_decap_8
XFILLER_8_498 VPWR VGND sg13g2_decap_8
XFILLER_39_336 VPWR VGND sg13g2_decap_8
XFILLER_35_553 VPWR VGND sg13g2_decap_8
XFILLER_23_704 VPWR VGND sg13g2_decap_8
Xfanout29 net32 net29 VPWR VGND sg13g2_buf_1
XFILLER_22_214 VPWR VGND sg13g2_decap_8
XFILLER_30_291 VPWR VGND sg13g2_decap_8
XFILLER_38_14 VPWR VGND sg13g2_decap_8
XFILLER_14_715 VPWR VGND sg13g2_decap_8
XFILLER_26_564 VPWR VGND sg13g2_decap_8
XFILLER_13_225 VPWR VGND sg13g2_decap_8
XFILLER_41_567 VPWR VGND sg13g2_decap_8
XFILLER_9_218 VPWR VGND sg13g2_decap_8
XFILLER_22_781 VPWR VGND sg13g2_decap_8
XFILLER_21_291 VPWR VGND sg13g2_decap_8
XFILLER_5_435 VPWR VGND sg13g2_decap_8
XFILLER_1_630 VPWR VGND sg13g2_decap_8
XFILLER_0_140 VPWR VGND sg13g2_decap_8
XFILLER_49_623 VPWR VGND sg13g2_decap_8
XFILLER_23_1005 VPWR VGND sg13g2_decap_8
XFILLER_48_133 VPWR VGND sg13g2_decap_8
XdigitalH.g\[100\].u.inv VPWR digitalH.g\[100\].u.OUTN net41 VGND sg13g2_inv_1
XFILLER_45_840 VPWR VGND sg13g2_decap_8
XFILLER_44_350 VPWR VGND sg13g2_decap_8
XFILLER_17_575 VPWR VGND sg13g2_decap_8
XFILLER_32_501 VPWR VGND sg13g2_decap_8
XFILLER_32_578 VPWR VGND sg13g2_decap_8
XFILLER_20_718 VPWR VGND sg13g2_decap_8
XFILLER_12_291 VPWR VGND sg13g2_decap_8
XFILLER_8_295 VPWR VGND sg13g2_decap_8
XFILLER_39_133 VPWR VGND sg13g2_decap_8
XFILLER_35_350 VPWR VGND sg13g2_decap_8
XdigitalH.g\[36\].u.inv VPWR digitalH.g\[36\].u.OUTN net44 VGND sg13g2_inv_1
XFILLER_23_501 VPWR VGND sg13g2_decap_8
XFILLER_11_729 VPWR VGND sg13g2_decap_8
XFILLER_23_578 VPWR VGND sg13g2_decap_8
XFILLER_3_939 VPWR VGND sg13g2_decap_8
XFILLER_49_35 VPWR VGND sg13g2_decap_8
XFILLER_2_449 VPWR VGND sg13g2_decap_8
XFILLER_46_637 VPWR VGND sg13g2_decap_8
XFILLER_45_147 VPWR VGND sg13g2_decap_8
XFILLER_27_840 VPWR VGND sg13g2_decap_8
XFILLER_14_512 VPWR VGND sg13g2_decap_8
XFILLER_26_361 VPWR VGND sg13g2_decap_8
XFILLER_14_589 VPWR VGND sg13g2_decap_8
XFILLER_41_364 VPWR VGND sg13g2_decap_8
XFILLER_14_71 VPWR VGND sg13g2_decap_8
XFILLER_6_722 VPWR VGND sg13g2_decap_8
XFILLER_5_232 VPWR VGND sg13g2_decap_8
XFILLER_6_777 VPWR VGND sg13g2_decap_8
XFILLER_30_81 VPWR VGND sg13g2_decap_8
XdigitalL.g\[67\].u.buff net110 digitalL.g\[67\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_7 VPWR VGND sg13g2_decap_8
XFILLER_49_420 VPWR VGND sg13g2_decap_8
XFILLER_49_497 VPWR VGND sg13g2_decap_8
XFILLER_37_637 VPWR VGND sg13g2_decap_8
XFILLER_36_147 VPWR VGND sg13g2_decap_8
XFILLER_17_372 VPWR VGND sg13g2_decap_8
XFILLER_18_873 VPWR VGND sg13g2_fill_1
XFILLER_32_375 VPWR VGND sg13g2_decap_8
XFILLER_20_515 VPWR VGND sg13g2_decap_8
XFILLER_9_582 VPWR VGND sg13g2_decap_8
XFILLER_19_16 VPWR VGND sg13g2_decap_8
XFILLER_28_648 VPWR VGND sg13g2_decap_8
XFILLER_27_147 VPWR VGND sg13g2_decap_8
XFILLER_15_309 VPWR VGND sg13g2_decap_8
XFILLER_24_865 VPWR VGND sg13g2_decap_8
XFILLER_23_375 VPWR VGND sg13g2_decap_8
XFILLER_11_526 VPWR VGND sg13g2_decap_8
XFILLER_7_519 VPWR VGND sg13g2_decap_8
XdigitalL.g\[91\].u.inv VPWR digitalL.g\[91\].u.OUTN net97 VGND sg13g2_inv_1
XFILLER_3_736 VPWR VGND sg13g2_decap_8
XFILLER_2_246 VPWR VGND sg13g2_decap_8
XFILLER_47_924 VPWR VGND sg13g2_decap_8
XFILLER_19_604 VPWR VGND sg13g2_decap_8
XFILLER_46_434 VPWR VGND sg13g2_decap_8
XFILLER_18_169 VPWR VGND sg13g2_decap_8
XFILLER_42_651 VPWR VGND sg13g2_decap_8
XFILLER_25_81 VPWR VGND sg13g2_decap_8
XFILLER_14_386 VPWR VGND sg13g2_decap_8
XFILLER_41_161 VPWR VGND sg13g2_decap_8
XFILLER_41_91 VPWR VGND sg13g2_decap_8
XFILLER_6_596 VPWR VGND sg13g2_decap_8
XdigitalH.g\[58\].u.buff net54 digitalH.g\[58\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_37_434 VPWR VGND sg13g2_decap_8
XFILLER_2_85 VPWR VGND sg13g2_decap_8
XFILLER_49_294 VPWR VGND sg13g2_decap_8
XFILLER_33_651 VPWR VGND sg13g2_decap_8
XFILLER_21_813 VPWR VGND sg13g2_decap_8
XFILLER_32_172 VPWR VGND sg13g2_decap_8
XFILLER_20_312 VPWR VGND sg13g2_decap_8
XFILLER_20_389 VPWR VGND sg13g2_decap_8
XFILLER_21_39 VPWR VGND sg13g2_decap_8
XFILLER_0_728 VPWR VGND sg13g2_decap_8
XFILLER_46_14 VPWR VGND sg13g2_decap_8
XFILLER_29_935 VPWR VGND sg13g2_decap_8
XFILLER_28_445 VPWR VGND sg13g2_decap_8
XFILLER_15_106 VPWR VGND sg13g2_decap_8
XdigitalL.g\[38\].u.inv VPWR digitalL.g\[38\].u.OUTN net93 VGND sg13g2_inv_1
XFILLER_44_927 VPWR VGND sg13g2_decap_8
XFILLER_43_448 VPWR VGND sg13g2_decap_8
XFILLER_30_109 VPWR VGND sg13g2_decap_8
XFILLER_24_662 VPWR VGND sg13g2_decap_8
XFILLER_11_323 VPWR VGND sg13g2_decap_8
XFILLER_23_172 VPWR VGND sg13g2_decap_8
XFILLER_7_316 VPWR VGND sg13g2_decap_8
XFILLER_11_50 VPWR VGND sg13g2_decap_8
XFILLER_3_533 VPWR VGND sg13g2_decap_8
XFILLER_4_1002 VPWR VGND sg13g2_decap_8
XFILLER_47_721 VPWR VGND sg13g2_decap_8
XFILLER_19_401 VPWR VGND sg13g2_decap_8
XFILLER_46_231 VPWR VGND sg13g2_decap_8
XFILLER_47_798 VPWR VGND sg13g2_decap_8
XFILLER_19_478 VPWR VGND sg13g2_decap_8
XFILLER_36_91 VPWR VGND sg13g2_decap_8
XFILLER_34_448 VPWR VGND sg13g2_decap_8
XFILLER_15_673 VPWR VGND sg13g2_decap_8
XFILLER_21_109 VPWR VGND sg13g2_decap_8
XFILLER_14_183 VPWR VGND sg13g2_decap_8
XFILLER_30_676 VPWR VGND sg13g2_decap_8
XdigitalL.g\[82\].u.buff net100 digitalL.g\[82\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[11\].u.buff net73 digitalL.g\[11\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_6_393 VPWR VGND sg13g2_decap_8
XdigitalH.g\[6\].u.buff net24 digitalH.g\[6\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_721 VPWR VGND sg13g2_decap_8
XdigitalH.g\[105\].u.buff net40 digitalH.g\[105\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_37_231 VPWR VGND sg13g2_decap_8
XFILLER_26_949 VPWR VGND sg13g2_decap_8
XFILLER_12_109 VPWR VGND sg13g2_decap_8
XFILLER_25_459 VPWR VGND sg13g2_decap_8
XFILLER_21_676 VPWR VGND sg13g2_decap_8
XFILLER_20_186 VPWR VGND sg13g2_decap_8
XFILLER_0_525 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[3\].u.inv VPWR digitalenL.g\[3\].u.OUTN net3 VGND sg13g2_inv_1
XFILLER_48_518 VPWR VGND sg13g2_decap_8
XFILLER_29_732 VPWR VGND sg13g2_decap_8
XFILLER_28_242 VPWR VGND sg13g2_decap_8
XFILLER_44_735 VPWR VGND sg13g2_decap_8
XFILLER_43_245 VPWR VGND sg13g2_decap_8
XdigitalH.g\[84\].u.inv VPWR digitalH.g\[84\].u.OUTN net57 VGND sg13g2_inv_1
XFILLER_11_120 VPWR VGND sg13g2_decap_8
XFILLER_8_603 VPWR VGND sg13g2_decap_8
XFILLER_12_676 VPWR VGND sg13g2_decap_8
XFILLER_7_113 VPWR VGND sg13g2_decap_8
XFILLER_11_197 VPWR VGND sg13g2_decap_8
XFILLER_22_60 VPWR VGND sg13g2_decap_8
XFILLER_4_820 VPWR VGND sg13g2_decap_8
XFILLER_3_330 VPWR VGND sg13g2_decap_8
XFILLER_4_897 VPWR VGND sg13g2_decap_8
XFILLER_39_518 VPWR VGND sg13g2_decap_8
XFILLER_47_595 VPWR VGND sg13g2_decap_8
XFILLER_19_275 VPWR VGND sg13g2_decap_8
XFILLER_34_245 VPWR VGND sg13g2_decap_8
XFILLER_15_470 VPWR VGND sg13g2_decap_8
XFILLER_31_952 VPWR VGND sg13g2_fill_1
XFILLER_30_473 VPWR VGND sg13g2_decap_8
XFILLER_7_680 VPWR VGND sg13g2_decap_8
XFILLER_6_190 VPWR VGND sg13g2_decap_8
XdigitalH.g\[73\].u.buff net61 digitalH.g\[73\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_27_49 VPWR VGND sg13g2_decap_8
XFILLER_38_595 VPWR VGND sg13g2_decap_8
XFILLER_26_746 VPWR VGND sg13g2_decap_8
XFILLER_13_407 VPWR VGND sg13g2_decap_8
XFILLER_25_256 VPWR VGND sg13g2_decap_8
XFILLER_40_259 VPWR VGND sg13g2_decap_8
XFILLER_22_963 VPWR VGND sg13g2_decap_8
XFILLER_21_473 VPWR VGND sg13g2_decap_8
XFILLER_5_617 VPWR VGND sg13g2_decap_8
XFILLER_4_127 VPWR VGND sg13g2_decap_8
XFILLER_1_812 VPWR VGND sg13g2_decap_8
XFILLER_0_322 VPWR VGND sg13g2_decap_8
XFILLER_49_805 VPWR VGND sg13g2_decap_8
XFILLER_48_315 VPWR VGND sg13g2_decap_8
XFILLER_1_889 VPWR VGND sg13g2_decap_8
XFILLER_0_399 VPWR VGND sg13g2_decap_8
XFILLER_44_532 VPWR VGND sg13g2_decap_8
XFILLER_17_71 VPWR VGND sg13g2_decap_8
XFILLER_16_267 VPWR VGND sg13g2_decap_8
XFILLER_12_473 VPWR VGND sg13g2_decap_8
XFILLER_8_400 VPWR VGND sg13g2_decap_8
XFILLER_33_70 VPWR VGND sg13g2_decap_8
XFILLER_8_477 VPWR VGND sg13g2_decap_8
XFILLER_4_694 VPWR VGND sg13g2_decap_8
XFILLER_39_315 VPWR VGND sg13g2_decap_8
XFILLER_48_882 VPWR VGND sg13g2_decap_8
XFILLER_47_392 VPWR VGND sg13g2_decap_8
XFILLER_35_532 VPWR VGND sg13g2_decap_8
XFILLER_13_29 VPWR VGND sg13g2_decap_8
XFILLER_31_771 VPWR VGND sg13g2_fill_2
XFILLER_30_270 VPWR VGND sg13g2_decap_8
XdigitalH.g\[32\].u.inv VPWR digitalH.g\[32\].u.OUTN net31 VGND sg13g2_inv_1
XFILLER_1_119 VPWR VGND sg13g2_decap_8
XdigitalH.g\[120\].u.buff net34 digitalH.g\[120\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_819 VPWR VGND sg13g2_decap_8
XFILLER_45_329 VPWR VGND sg13g2_decap_8
XFILLER_38_392 VPWR VGND sg13g2_decap_8
XFILLER_26_543 VPWR VGND sg13g2_decap_8
XFILLER_13_204 VPWR VGND sg13g2_decap_8
XFILLER_14_738 VPWR VGND sg13g2_fill_1
XFILLER_41_546 VPWR VGND sg13g2_decap_8
XFILLER_22_760 VPWR VGND sg13g2_decap_8
XFILLER_21_270 VPWR VGND sg13g2_decap_8
XFILLER_6_915 VPWR VGND sg13g2_decap_8
XFILLER_5_414 VPWR VGND sg13g2_decap_8
XFILLER_49_602 VPWR VGND sg13g2_decap_8
XFILLER_1_686 VPWR VGND sg13g2_decap_8
XFILLER_0_196 VPWR VGND sg13g2_decap_8
XFILLER_48_112 VPWR VGND sg13g2_decap_8
XFILLER_23_1028 VPWR VGND sg13g2_fill_1
XFILLER_49_679 VPWR VGND sg13g2_decap_8
XFILLER_48_189 VPWR VGND sg13g2_decap_8
XFILLER_36_329 VPWR VGND sg13g2_decap_8
XFILLER_28_81 VPWR VGND sg13g2_decap_8
XFILLER_17_554 VPWR VGND sg13g2_decap_8
XdigitalL.g\[86\].u.inv VPWR digitalL.g\[86\].u.OUTN net99 VGND sg13g2_inv_1
XFILLER_45_896 VPWR VGND sg13g2_decap_8
XFILLER_32_557 VPWR VGND sg13g2_decap_8
XFILLER_44_91 VPWR VGND sg13g2_decap_8
XFILLER_12_270 VPWR VGND sg13g2_decap_8
XFILLER_8_274 VPWR VGND sg13g2_decap_8
XFILLER_5_981 VPWR VGND sg13g2_decap_8
XFILLER_4_491 VPWR VGND sg13g2_decap_8
XFILLER_5_85 VPWR VGND sg13g2_decap_8
XFILLER_39_112 VPWR VGND sg13g2_decap_8
XFILLER_39_189 VPWR VGND sg13g2_decap_8
XFILLER_27_329 VPWR VGND sg13g2_decap_8
XdigitalL.g\[110\].u.buff net79 digitalL.g\[110\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_24_39 VPWR VGND sg13g2_decap_8
XFILLER_23_557 VPWR VGND sg13g2_decap_8
XFILLER_11_708 VPWR VGND sg13g2_decap_8
XFILLER_10_229 VPWR VGND sg13g2_decap_8
XFILLER_40_49 VPWR VGND sg13g2_decap_8
XFILLER_3_918 VPWR VGND sg13g2_decap_8
XFILLER_2_428 VPWR VGND sg13g2_decap_8
XFILLER_6_8 VPWR VGND sg13g2_decap_8
XFILLER_49_14 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[0\].u.buff net3 digitalenL.g\[0\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_616 VPWR VGND sg13g2_decap_8
XFILLER_45_126 VPWR VGND sg13g2_decap_8
XFILLER_26_340 VPWR VGND sg13g2_decap_8
XFILLER_27_896 VPWR VGND sg13g2_decap_8
XFILLER_14_568 VPWR VGND sg13g2_decap_8
XFILLER_42_899 VPWR VGND sg13g2_fill_1
XFILLER_41_343 VPWR VGND sg13g2_decap_8
XFILLER_10_730 VPWR VGND sg13g2_fill_1
XFILLER_14_50 VPWR VGND sg13g2_decap_8
XFILLER_6_701 VPWR VGND sg13g2_decap_8
XFILLER_5_211 VPWR VGND sg13g2_decap_8
XFILLER_5_288 VPWR VGND sg13g2_decap_8
XFILLER_30_60 VPWR VGND sg13g2_decap_8
XFILLER_2_995 VPWR VGND sg13g2_decap_8
XFILLER_1_483 VPWR VGND sg13g2_decap_8
XFILLER_49_476 VPWR VGND sg13g2_decap_8
XFILLER_39_91 VPWR VGND sg13g2_decap_8
XFILLER_37_616 VPWR VGND sg13g2_decap_8
XdigitalL.g\[36\].u.buff net92 digitalL.g\[36\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_126 VPWR VGND sg13g2_decap_8
XFILLER_17_351 VPWR VGND sg13g2_decap_8
XdigitalL.g\[1\].u.buff net70 digitalL.g\[1\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_693 VPWR VGND sg13g2_decap_8
XFILLER_32_354 VPWR VGND sg13g2_decap_8
XFILLER_9_561 VPWR VGND sg13g2_decap_8
XFILLER_10_19 VPWR VGND sg13g2_decap_8
XFILLER_28_627 VPWR VGND sg13g2_decap_8
XFILLER_27_126 VPWR VGND sg13g2_decap_8
XFILLER_35_49 VPWR VGND sg13g2_decap_8
XFILLER_36_693 VPWR VGND sg13g2_decap_8
XFILLER_24_844 VPWR VGND sg13g2_decap_8
XFILLER_11_505 VPWR VGND sg13g2_decap_8
XFILLER_23_354 VPWR VGND sg13g2_decap_8
XdigitalL.g\[34\].u.inv VPWR digitalL.g\[34\].u.OUTN net92 VGND sg13g2_inv_1
XFILLER_3_715 VPWR VGND sg13g2_decap_8
XFILLER_2_225 VPWR VGND sg13g2_decap_8
XFILLER_47_903 VPWR VGND sg13g2_decap_8
XFILLER_46_413 VPWR VGND sg13g2_decap_8
XFILLER_18_148 VPWR VGND sg13g2_decap_8
XFILLER_42_630 VPWR VGND sg13g2_decap_8
XFILLER_27_693 VPWR VGND sg13g2_decap_8
XFILLER_14_365 VPWR VGND sg13g2_decap_8
XFILLER_41_140 VPWR VGND sg13g2_decap_8
XFILLER_25_60 VPWR VGND sg13g2_decap_8
XFILLER_10_593 VPWR VGND sg13g2_decap_8
XFILLER_41_70 VPWR VGND sg13g2_decap_8
XFILLER_6_575 VPWR VGND sg13g2_decap_8
XFILLER_29_1012 VPWR VGND sg13g2_decap_8
XdigitalH.g\[79\].u.inv VPWR digitalH.g\[79\].u.OUTN net58 VGND sg13g2_inv_1
XFILLER_2_792 VPWR VGND sg13g2_decap_8
XFILLER_1_280 VPWR VGND sg13g2_decap_8
XFILLER_49_273 VPWR VGND sg13g2_decap_8
XFILLER_37_413 VPWR VGND sg13g2_decap_8
XFILLER_2_64 VPWR VGND sg13g2_decap_8
XdigitalH.g\[98\].u.buff net41 digitalH.g\[98\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[27\].u.buff net31 digitalH.g\[27\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_980 VPWR VGND sg13g2_decap_8
XFILLER_45_490 VPWR VGND sg13g2_decap_8
XFILLER_33_630 VPWR VGND sg13g2_decap_8
XFILLER_32_151 VPWR VGND sg13g2_decap_8
XFILLER_21_869 VPWR VGND sg13g2_decap_8
XFILLER_21_18 VPWR VGND sg13g2_decap_8
XFILLER_20_368 VPWR VGND sg13g2_decap_8
XFILLER_0_707 VPWR VGND sg13g2_decap_8
XFILLER_29_914 VPWR VGND sg13g2_decap_8
XFILLER_28_424 VPWR VGND sg13g2_decap_8
XFILLER_44_906 VPWR VGND sg13g2_decap_8
XFILLER_43_427 VPWR VGND sg13g2_decap_8
XFILLER_36_490 VPWR VGND sg13g2_decap_8
XFILLER_24_641 VPWR VGND sg13g2_decap_8
XFILLER_11_302 VPWR VGND sg13g2_decap_8
XFILLER_23_151 VPWR VGND sg13g2_decap_8
XFILLER_11_379 VPWR VGND sg13g2_decap_8
XFILLER_20_880 VPWR VGND sg13g2_decap_8
XFILLER_3_512 VPWR VGND sg13g2_decap_8
XdigitalH.g\[80\].u.inv VPWR digitalH.g\[80\].u.OUTN net58 VGND sg13g2_inv_1
XFILLER_3_589 VPWR VGND sg13g2_decap_8
XFILLER_47_700 VPWR VGND sg13g2_decap_8
XFILLER_46_210 VPWR VGND sg13g2_decap_8
XFILLER_19_457 VPWR VGND sg13g2_decap_8
XFILLER_47_777 VPWR VGND sg13g2_decap_8
XFILLER_46_287 VPWR VGND sg13g2_decap_8
XFILLER_36_70 VPWR VGND sg13g2_decap_8
XFILLER_34_427 VPWR VGND sg13g2_decap_8
XFILLER_28_991 VPWR VGND sg13g2_decap_8
XFILLER_27_490 VPWR VGND sg13g2_decap_8
XFILLER_15_652 VPWR VGND sg13g2_decap_8
XFILLER_14_162 VPWR VGND sg13g2_decap_8
XFILLER_30_655 VPWR VGND sg13g2_decap_8
XFILLER_7_840 VPWR VGND sg13g2_decap_4
XFILLER_10_390 VPWR VGND sg13g2_decap_8
XFILLER_7_873 VPWR VGND sg13g2_fill_1
XFILLER_6_372 VPWR VGND sg13g2_decap_8
XdigitalL.g\[51\].u.buff net102 digitalL.g\[51\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_700 VPWR VGND sg13g2_decap_8
XFILLER_37_210 VPWR VGND sg13g2_decap_8
XFILLER_26_928 VPWR VGND sg13g2_decap_8
XFILLER_16_29 VPWR VGND sg13g2_decap_8
XFILLER_37_287 VPWR VGND sg13g2_decap_8
XFILLER_25_438 VPWR VGND sg13g2_decap_8
XFILLER_21_655 VPWR VGND sg13g2_decap_8
XFILLER_32_39 VPWR VGND sg13g2_decap_8
XFILLER_20_165 VPWR VGND sg13g2_decap_8
XFILLER_4_309 VPWR VGND sg13g2_decap_8
XFILLER_0_504 VPWR VGND sg13g2_decap_8
XFILLER_29_711 VPWR VGND sg13g2_decap_8
XFILLER_28_221 VPWR VGND sg13g2_decap_8
XFILLER_44_714 VPWR VGND sg13g2_decap_8
XFILLER_29_788 VPWR VGND sg13g2_decap_8
XFILLER_16_449 VPWR VGND sg13g2_decap_8
XFILLER_43_224 VPWR VGND sg13g2_decap_8
XFILLER_28_298 VPWR VGND sg13g2_decap_8
XdigitalH.g\[27\].u.inv VPWR digitalH.g\[27\].u.OUTN net30 VGND sg13g2_inv_1
XFILLER_12_655 VPWR VGND sg13g2_decap_8
XFILLER_11_176 VPWR VGND sg13g2_decap_8
XFILLER_8_659 VPWR VGND sg13g2_decap_8
XFILLER_7_169 VPWR VGND sg13g2_decap_8
XFILLER_4_876 VPWR VGND sg13g2_decap_8
XFILLER_3_386 VPWR VGND sg13g2_decap_8
XFILLER_26_1026 VPWR VGND sg13g2_fill_2
XFILLER_47_91 VPWR VGND sg13g2_decap_8
XFILLER_47_574 VPWR VGND sg13g2_decap_8
XFILLER_35_714 VPWR VGND sg13g2_decap_8
XFILLER_19_254 VPWR VGND sg13g2_decap_8
XFILLER_35_736 VPWR VGND sg13g2_fill_2
XFILLER_34_224 VPWR VGND sg13g2_decap_8
XFILLER_30_452 VPWR VGND sg13g2_decap_8
XFILLER_8_85 VPWR VGND sg13g2_decap_8
XFILLER_40_0 VPWR VGND sg13g2_decap_8
XdigitalH.g\[42\].u.buff net47 digitalH.g\[42\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_574 VPWR VGND sg13g2_decap_8
XFILLER_27_28 VPWR VGND sg13g2_decap_8
XFILLER_26_725 VPWR VGND sg13g2_decap_8
XFILLER_25_235 VPWR VGND sg13g2_decap_8
XFILLER_41_728 VPWR VGND sg13g2_fill_1
XFILLER_43_49 VPWR VGND sg13g2_decap_8
XFILLER_40_238 VPWR VGND sg13g2_decap_8
XFILLER_22_942 VPWR VGND sg13g2_decap_8
XFILLER_21_452 VPWR VGND sg13g2_decap_8
XFILLER_4_106 VPWR VGND sg13g2_decap_8
XFILLER_49_1015 VPWR VGND sg13g2_decap_8
XFILLER_0_301 VPWR VGND sg13g2_decap_8
XFILLER_1_868 VPWR VGND sg13g2_decap_8
XFILLER_0_378 VPWR VGND sg13g2_decap_8
XFILLER_17_50 VPWR VGND sg13g2_decap_8
XFILLER_44_511 VPWR VGND sg13g2_decap_8
XFILLER_29_585 VPWR VGND sg13g2_decap_8
XFILLER_16_246 VPWR VGND sg13g2_decap_8
XFILLER_44_588 VPWR VGND sg13g2_decap_8
XFILLER_32_739 VPWR VGND sg13g2_decap_8
XFILLER_31_249 VPWR VGND sg13g2_decap_8
XFILLER_12_452 VPWR VGND sg13g2_decap_8
XFILLER_8_456 VPWR VGND sg13g2_decap_8
XdigitalL.g\[82\].u.inv VPWR digitalL.g\[82\].u.OUTN net100 VGND sg13g2_inv_1
XFILLER_4_673 VPWR VGND sg13g2_decap_8
XFILLER_3_183 VPWR VGND sg13g2_decap_8
XFILLER_12_4 VPWR VGND sg13g2_decap_8
XFILLER_48_861 VPWR VGND sg13g2_decap_8
XFILLER_47_371 VPWR VGND sg13g2_decap_8
XFILLER_35_511 VPWR VGND sg13g2_decap_8
XFILLER_35_588 VPWR VGND sg13g2_decap_8
XFILLER_23_739 VPWR VGND sg13g2_decap_8
XFILLER_22_249 VPWR VGND sg13g2_decap_8
XFILLER_38_49 VPWR VGND sg13g2_decap_8
XFILLER_45_308 VPWR VGND sg13g2_decap_8
XFILLER_38_371 VPWR VGND sg13g2_decap_8
XFILLER_26_522 VPWR VGND sg13g2_decap_8
XFILLER_41_525 VPWR VGND sg13g2_decap_8
XFILLER_26_599 VPWR VGND sg13g2_decap_8
XFILLER_6_949 VPWR VGND sg13g2_decap_8
XFILLER_1_665 VPWR VGND sg13g2_decap_8
XFILLER_0_175 VPWR VGND sg13g2_decap_8
XFILLER_49_658 VPWR VGND sg13g2_decap_8
XFILLER_48_168 VPWR VGND sg13g2_decap_8
XFILLER_36_308 VPWR VGND sg13g2_decap_8
XFILLER_29_382 VPWR VGND sg13g2_decap_8
XFILLER_28_60 VPWR VGND sg13g2_decap_8
XFILLER_17_533 VPWR VGND sg13g2_decap_8
XdigitalL.g\[29\].u.inv VPWR digitalL.g\[29\].u.OUTN net83 VGND sg13g2_inv_1
XFILLER_45_875 VPWR VGND sg13g2_decap_8
XFILLER_44_70 VPWR VGND sg13g2_decap_8
XFILLER_44_385 VPWR VGND sg13g2_decap_8
XFILLER_32_536 VPWR VGND sg13g2_decap_8
XFILLER_8_253 VPWR VGND sg13g2_decap_8
XFILLER_5_960 VPWR VGND sg13g2_decap_8
XFILLER_4_470 VPWR VGND sg13g2_decap_8
XFILLER_5_64 VPWR VGND sg13g2_decap_8
XFILLER_39_168 VPWR VGND sg13g2_decap_8
XFILLER_28_809 VPWR VGND sg13g2_decap_8
XFILLER_27_308 VPWR VGND sg13g2_decap_8
XFILLER_35_385 VPWR VGND sg13g2_decap_8
XFILLER_24_18 VPWR VGND sg13g2_decap_8
XFILLER_23_536 VPWR VGND sg13g2_decap_8
XFILLER_10_208 VPWR VGND sg13g2_decap_8
XFILLER_40_28 VPWR VGND sg13g2_decap_8
XFILLER_2_407 VPWR VGND sg13g2_decap_8
XFILLER_45_105 VPWR VGND sg13g2_decap_8
XdigitalL.g\[30\].u.inv VPWR digitalL.g\[30\].u.OUTN net84 VGND sg13g2_inv_1
XFILLER_42_812 VPWR VGND sg13g2_fill_1
XFILLER_27_875 VPWR VGND sg13g2_decap_8
XFILLER_14_547 VPWR VGND sg13g2_decap_8
XFILLER_41_322 VPWR VGND sg13g2_decap_8
XFILLER_26_396 VPWR VGND sg13g2_decap_8
XFILLER_41_399 VPWR VGND sg13g2_decap_8
XFILLER_6_757 VPWR VGND sg13g2_decap_8
XFILLER_5_267 VPWR VGND sg13g2_decap_8
XFILLER_2_974 VPWR VGND sg13g2_decap_8
XFILLER_1_462 VPWR VGND sg13g2_decap_8
XFILLER_49_455 VPWR VGND sg13g2_decap_8
XFILLER_39_70 VPWR VGND sg13g2_decap_8
XFILLER_36_105 VPWR VGND sg13g2_decap_8
XFILLER_17_330 VPWR VGND sg13g2_decap_8
XdigitalL.g\[125\].u.inv VPWR digitalL.g\[125\].u.OUTN net69 VGND sg13g2_inv_1
XdigitalL.g\[76\].u.buff net107 digitalL.g\[76\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_45_672 VPWR VGND sg13g2_decap_8
XFILLER_18_886 VPWR VGND sg13g2_fill_1
XFILLER_44_182 VPWR VGND sg13g2_decap_8
XdigitalH.g\[75\].u.inv VPWR digitalH.g\[75\].u.OUTN net60 VGND sg13g2_inv_1
XFILLER_32_333 VPWR VGND sg13g2_decap_8
XFILLER_9_540 VPWR VGND sg13g2_decap_8
XFILLER_28_606 VPWR VGND sg13g2_decap_8
XFILLER_27_105 VPWR VGND sg13g2_decap_8
XFILLER_43_609 VPWR VGND sg13g2_decap_8
XFILLER_36_672 VPWR VGND sg13g2_decap_8
XFILLER_35_28 VPWR VGND sg13g2_decap_8
XFILLER_42_119 VPWR VGND sg13g2_decap_8
XFILLER_35_182 VPWR VGND sg13g2_decap_8
XFILLER_24_823 VPWR VGND sg13g2_decap_8
XFILLER_23_333 VPWR VGND sg13g2_decap_8
XFILLER_2_204 VPWR VGND sg13g2_decap_8
XFILLER_19_639 VPWR VGND sg13g2_decap_8
XFILLER_18_127 VPWR VGND sg13g2_decap_8
XFILLER_47_959 VPWR VGND sg13g2_decap_8
XFILLER_46_469 VPWR VGND sg13g2_decap_8
XFILLER_34_609 VPWR VGND sg13g2_decap_8
XFILLER_27_672 VPWR VGND sg13g2_decap_8
XFILLER_33_119 VPWR VGND sg13g2_decap_8
XFILLER_14_344 VPWR VGND sg13g2_decap_8
XFILLER_26_193 VPWR VGND sg13g2_decap_8
XFILLER_42_686 VPWR VGND sg13g2_decap_8
XFILLER_30_848 VPWR VGND sg13g2_fill_1
XFILLER_41_196 VPWR VGND sg13g2_decap_8
XFILLER_10_572 VPWR VGND sg13g2_decap_8
XFILLER_6_554 VPWR VGND sg13g2_decap_8
Xheichips25_pudding VPWR VGND uio_oe[0] sg13g2_tiehi
XFILLER_44_7 VPWR VGND sg13g2_decap_8
XFILLER_2_771 VPWR VGND sg13g2_decap_8
XFILLER_2_43 VPWR VGND sg13g2_decap_8
XFILLER_49_252 VPWR VGND sg13g2_decap_8
XFILLER_37_469 VPWR VGND sg13g2_decap_8
XFILLER_18_694 VPWR VGND sg13g2_decap_8
XFILLER_32_130 VPWR VGND sg13g2_decap_8
XdigitalH.g\[67\].u.buff net63 digitalH.g\[67\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_33_686 VPWR VGND sg13g2_decap_8
XFILLER_21_848 VPWR VGND sg13g2_decap_8
XFILLER_20_347 VPWR VGND sg13g2_decap_8
XFILLER_28_403 VPWR VGND sg13g2_decap_8
XFILLER_46_49 VPWR VGND sg13g2_decap_8
XFILLER_43_406 VPWR VGND sg13g2_decap_8
XFILLER_24_620 VPWR VGND sg13g2_decap_8
XFILLER_23_130 VPWR VGND sg13g2_decap_8
XFILLER_24_697 VPWR VGND sg13g2_decap_8
XFILLER_11_358 VPWR VGND sg13g2_decap_8
XFILLER_11_85 VPWR VGND sg13g2_decap_8
XdigitalH.g\[23\].u.inv VPWR digitalH.g\[23\].u.OUTN net28 VGND sg13g2_inv_1
XFILLER_3_568 VPWR VGND sg13g2_decap_8
XFILLER_47_756 VPWR VGND sg13g2_decap_8
XFILLER_19_436 VPWR VGND sg13g2_decap_8
XFILLER_46_266 VPWR VGND sg13g2_decap_8
XFILLER_34_406 VPWR VGND sg13g2_decap_8
XFILLER_28_970 VPWR VGND sg13g2_decap_8
XFILLER_15_631 VPWR VGND sg13g2_decap_8
XFILLER_14_141 VPWR VGND sg13g2_decap_8
XFILLER_42_483 VPWR VGND sg13g2_decap_8
XFILLER_30_634 VPWR VGND sg13g2_decap_8
XFILLER_6_351 VPWR VGND sg13g2_decap_8
XFILLER_7_885 VPWR VGND sg13g2_fill_1
XdigitalL.g\[91\].u.buff net97 digitalL.g\[91\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[20\].u.buff net81 digitalL.g\[20\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_37_266 VPWR VGND sg13g2_decap_8
XFILLER_26_907 VPWR VGND sg13g2_decap_8
XFILLER_25_417 VPWR VGND sg13g2_decap_8
XdigitalL.g\[77\].u.inv VPWR digitalL.g\[77\].u.OUTN net107 VGND sg13g2_inv_1
XFILLER_18_491 VPWR VGND sg13g2_decap_8
XFILLER_33_483 VPWR VGND sg13g2_decap_8
XFILLER_32_18 VPWR VGND sg13g2_decap_8
XFILLER_21_634 VPWR VGND sg13g2_decap_8
XdigitalH.g\[114\].u.buff net36 digitalH.g\[114\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_144 VPWR VGND sg13g2_decap_8
XFILLER_28_200 VPWR VGND sg13g2_decap_8
XFILLER_29_767 VPWR VGND sg13g2_decap_8
XFILLER_16_428 VPWR VGND sg13g2_decap_8
XFILLER_43_203 VPWR VGND sg13g2_decap_8
XFILLER_28_277 VPWR VGND sg13g2_decap_8
XFILLER_25_984 VPWR VGND sg13g2_decap_8
XFILLER_12_634 VPWR VGND sg13g2_decap_8
XFILLER_24_494 VPWR VGND sg13g2_decap_8
XFILLER_11_155 VPWR VGND sg13g2_decap_8
XFILLER_8_638 VPWR VGND sg13g2_decap_8
XFILLER_7_148 VPWR VGND sg13g2_decap_8
XFILLER_22_95 VPWR VGND sg13g2_decap_8
XFILLER_4_855 VPWR VGND sg13g2_decap_8
XFILLER_0_0 VPWR VGND sg13g2_decap_8
XFILLER_3_365 VPWR VGND sg13g2_decap_8
XFILLER_26_1005 VPWR VGND sg13g2_decap_8
XdigitalH.g\[6\].u.inv VPWR digitalH.g\[6\].u.OUTN net38 VGND sg13g2_inv_1
XFILLER_14_8 VPWR VGND sg13g2_decap_8
XFILLER_47_70 VPWR VGND sg13g2_decap_8
XFILLER_47_553 VPWR VGND sg13g2_decap_8
XFILLER_19_233 VPWR VGND sg13g2_decap_8
XFILLER_34_203 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_116 VPWR VGND uio_oe[1] sg13g2_tiehi
XFILLER_42_280 VPWR VGND sg13g2_decap_8
XFILLER_30_431 VPWR VGND sg13g2_decap_8
XFILLER_8_64 VPWR VGND sg13g2_decap_8
XFILLER_33_0 VPWR VGND sg13g2_decap_8
XdigitalL.g\[104\].u.buff net87 digitalL.g\[104\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_553 VPWR VGND sg13g2_decap_8
XFILLER_26_704 VPWR VGND sg13g2_decap_8
XdigitalH.g\[82\].u.buff net58 digitalH.g\[82\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_25_214 VPWR VGND sg13g2_decap_8
XdigitalH.g\[11\].u.buff net26 digitalH.g\[11\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_41_707 VPWR VGND sg13g2_decap_8
XFILLER_43_28 VPWR VGND sg13g2_decap_8
XFILLER_40_217 VPWR VGND sg13g2_decap_8
XFILLER_22_921 VPWR VGND sg13g2_decap_8
XFILLER_33_280 VPWR VGND sg13g2_decap_8
XFILLER_21_431 VPWR VGND sg13g2_decap_8
XFILLER_22_998 VPWR VGND sg13g2_decap_8
XFILLER_1_847 VPWR VGND sg13g2_decap_8
XFILLER_0_357 VPWR VGND sg13g2_decap_8
XFILLER_29_564 VPWR VGND sg13g2_decap_8
XFILLER_17_715 VPWR VGND sg13g2_decap_4
XFILLER_16_225 VPWR VGND sg13g2_decap_8
XFILLER_44_567 VPWR VGND sg13g2_decap_8
XFILLER_32_718 VPWR VGND sg13g2_decap_8
XFILLER_31_228 VPWR VGND sg13g2_decap_8
XFILLER_25_781 VPWR VGND sg13g2_decap_8
XFILLER_12_431 VPWR VGND sg13g2_decap_8
XFILLER_24_291 VPWR VGND sg13g2_decap_8
XFILLER_8_435 VPWR VGND sg13g2_decap_8
XFILLER_4_652 VPWR VGND sg13g2_decap_8
XdigitalL.g\[25\].u.inv VPWR digitalL.g\[25\].u.OUTN net82 VGND sg13g2_inv_1
XFILLER_3_162 VPWR VGND sg13g2_decap_8
XFILLER_48_840 VPWR VGND sg13g2_decap_8
XFILLER_47_350 VPWR VGND sg13g2_decap_8
XFILLER_35_567 VPWR VGND sg13g2_decap_8
XFILLER_23_718 VPWR VGND sg13g2_decap_8
XFILLER_22_228 VPWR VGND sg13g2_decap_8
XFILLER_38_28 VPWR VGND sg13g2_decap_8
XFILLER_38_350 VPWR VGND sg13g2_decap_8
XFILLER_26_501 VPWR VGND sg13g2_decap_8
XFILLER_14_729 VPWR VGND sg13g2_decap_8
XFILLER_41_504 VPWR VGND sg13g2_decap_8
XFILLER_26_578 VPWR VGND sg13g2_decap_8
XFILLER_13_239 VPWR VGND sg13g2_decap_8
XFILLER_22_795 VPWR VGND sg13g2_decap_8
XFILLER_6_928 VPWR VGND sg13g2_decap_8
XFILLER_5_449 VPWR VGND sg13g2_decap_8
XFILLER_1_644 VPWR VGND sg13g2_decap_8
XFILLER_0_154 VPWR VGND sg13g2_decap_8
XFILLER_49_637 VPWR VGND sg13g2_decap_8
XFILLER_23_1019 VPWR VGND sg13g2_decap_8
XFILLER_48_147 VPWR VGND sg13g2_decap_8
XFILLER_17_512 VPWR VGND sg13g2_decap_8
XFILLER_29_361 VPWR VGND sg13g2_decap_8
XFILLER_45_854 VPWR VGND sg13g2_decap_8
XFILLER_17_589 VPWR VGND sg13g2_decap_8
XFILLER_44_364 VPWR VGND sg13g2_decap_8
XFILLER_32_515 VPWR VGND sg13g2_decap_8
XFILLER_9_722 VPWR VGND sg13g2_decap_8
XFILLER_40_581 VPWR VGND sg13g2_decap_8
XFILLER_8_232 VPWR VGND sg13g2_decap_8
XdigitalL.g\[121\].u.inv VPWR digitalL.g\[121\].u.OUTN net76 VGND sg13g2_inv_1
XFILLER_5_43 VPWR VGND sg13g2_decap_8
XdigitalH.g\[71\].u.inv VPWR digitalH.g\[71\].u.OUTN net62 VGND sg13g2_inv_1
XFILLER_39_147 VPWR VGND sg13g2_decap_8
XFILLER_35_364 VPWR VGND sg13g2_decap_8
XFILLER_23_515 VPWR VGND sg13g2_decap_8
XFILLER_31_592 VPWR VGND sg13g2_decap_8
XFILLER_46_1008 VPWR VGND sg13g2_decap_8
XFILLER_49_49 VPWR VGND sg13g2_decap_8
XFILLER_18_309 VPWR VGND sg13g2_decap_8
XFILLER_27_854 VPWR VGND sg13g2_decap_8
XFILLER_14_526 VPWR VGND sg13g2_decap_8
XFILLER_41_301 VPWR VGND sg13g2_decap_8
XFILLER_26_375 VPWR VGND sg13g2_decap_8
XFILLER_41_378 VPWR VGND sg13g2_decap_8
XFILLER_14_85 VPWR VGND sg13g2_decap_8
XFILLER_22_592 VPWR VGND sg13g2_decap_8
XFILLER_6_736 VPWR VGND sg13g2_decap_8
XFILLER_5_246 VPWR VGND sg13g2_decap_8
XFILLER_30_95 VPWR VGND sg13g2_decap_8
XFILLER_2_953 VPWR VGND sg13g2_decap_8
XFILLER_1_441 VPWR VGND sg13g2_decap_8
XFILLER_7_1024 VPWR VGND sg13g2_decap_4
XFILLER_49_434 VPWR VGND sg13g2_decap_8
XFILLER_18_843 VPWR VGND sg13g2_fill_2
XFILLER_18_832 VPWR VGND sg13g2_fill_1
XFILLER_45_651 VPWR VGND sg13g2_decap_8
XFILLER_18_865 VPWR VGND sg13g2_fill_1
XFILLER_17_386 VPWR VGND sg13g2_decap_8
XFILLER_44_161 VPWR VGND sg13g2_decap_8
XFILLER_32_312 VPWR VGND sg13g2_decap_8
XFILLER_18_898 VPWR VGND sg13g2_fill_2
XdigitalH.g\[18\].u.inv VPWR digitalH.g\[18\].u.OUTN net28 VGND sg13g2_inv_1
XFILLER_32_389 VPWR VGND sg13g2_decap_8
XFILLER_20_529 VPWR VGND sg13g2_decap_8
XdigitalL.g\[45\].u.buff net95 digitalL.g\[45\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_9_596 VPWR VGND sg13g2_decap_8
XFILLER_36_651 VPWR VGND sg13g2_decap_8
XFILLER_24_802 VPWR VGND sg13g2_decap_8
XFILLER_35_161 VPWR VGND sg13g2_decap_8
XFILLER_23_312 VPWR VGND sg13g2_decap_8
XFILLER_24_879 VPWR VGND sg13g2_decap_8
XFILLER_23_389 VPWR VGND sg13g2_decap_8
XFILLER_18_106 VPWR VGND sg13g2_decap_8
XFILLER_47_938 VPWR VGND sg13g2_decap_8
XFILLER_19_618 VPWR VGND sg13g2_decap_8
XFILLER_46_448 VPWR VGND sg13g2_decap_8
XFILLER_27_651 VPWR VGND sg13g2_decap_8
XFILLER_26_172 VPWR VGND sg13g2_decap_8
XFILLER_14_323 VPWR VGND sg13g2_decap_8
XFILLER_42_665 VPWR VGND sg13g2_decap_8
XFILLER_41_175 VPWR VGND sg13g2_decap_8
XFILLER_25_95 VPWR VGND sg13g2_decap_8
XFILLER_10_551 VPWR VGND sg13g2_decap_8
XFILLER_6_533 VPWR VGND sg13g2_decap_8
XFILLER_2_750 VPWR VGND sg13g2_decap_8
XFILLER_37_7 VPWR VGND sg13g2_decap_8
XFILLER_49_231 VPWR VGND sg13g2_decap_8
XFILLER_2_22 VPWR VGND sg13g2_decap_8
XFILLER_37_448 VPWR VGND sg13g2_decap_8
XFILLER_2_99 VPWR VGND sg13g2_decap_8
XFILLER_24_109 VPWR VGND sg13g2_decap_8
XFILLER_18_673 VPWR VGND sg13g2_decap_8
XFILLER_17_183 VPWR VGND sg13g2_decap_8
XFILLER_33_665 VPWR VGND sg13g2_decap_8
XFILLER_21_827 VPWR VGND sg13g2_decap_8
XFILLER_32_186 VPWR VGND sg13g2_decap_8
XFILLER_20_326 VPWR VGND sg13g2_decap_8
XFILLER_9_393 VPWR VGND sg13g2_decap_8
XdigitalH.g\[36\].u.buff net44 digitalH.g\[36\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[73\].u.inv VPWR digitalL.g\[73\].u.OUTN net108 VGND sg13g2_inv_1
XFILLER_46_28 VPWR VGND sg13g2_decap_8
XFILLER_29_949 VPWR VGND sg13g2_decap_8
XFILLER_28_459 VPWR VGND sg13g2_decap_8
XFILLER_24_676 VPWR VGND sg13g2_decap_8
XFILLER_11_337 VPWR VGND sg13g2_decap_8
XFILLER_23_186 VPWR VGND sg13g2_decap_8
XFILLER_11_64 VPWR VGND sg13g2_decap_8
XFILLER_3_547 VPWR VGND sg13g2_decap_8
XFILLER_4_1016 VPWR VGND sg13g2_decap_8
XFILLER_4_1027 VPWR VGND sg13g2_fill_2
XFILLER_47_735 VPWR VGND sg13g2_decap_8
XFILLER_19_415 VPWR VGND sg13g2_decap_8
XFILLER_46_245 VPWR VGND sg13g2_decap_8
XFILLER_15_610 VPWR VGND sg13g2_decap_8
XFILLER_14_120 VPWR VGND sg13g2_decap_8
XFILLER_15_687 VPWR VGND sg13g2_decap_8
XFILLER_42_462 VPWR VGND sg13g2_decap_8
XFILLER_30_613 VPWR VGND sg13g2_decap_8
XFILLER_14_197 VPWR VGND sg13g2_decap_8
XdigitalH.g\[2\].u.inv VPWR digitalH.g\[2\].u.OUTN net23 VGND sg13g2_inv_1
XFILLER_6_330 VPWR VGND sg13g2_decap_8
XFILLER_7_853 VPWR VGND sg13g2_fill_1
XFILLER_42_1000 VPWR VGND sg13g2_fill_1
XFILLER_38_735 VPWR VGND sg13g2_decap_4
XFILLER_37_245 VPWR VGND sg13g2_decap_8
XFILLER_18_470 VPWR VGND sg13g2_decap_8
XdigitalL.g\[60\].u.buff net104 digitalL.g\[60\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_33_462 VPWR VGND sg13g2_decap_8
XFILLER_21_613 VPWR VGND sg13g2_decap_8
XFILLER_20_123 VPWR VGND sg13g2_decap_8
XFILLER_9_190 VPWR VGND sg13g2_decap_8
XFILLER_0_539 VPWR VGND sg13g2_decap_8
XFILLER_29_746 VPWR VGND sg13g2_decap_8
XFILLER_28_256 VPWR VGND sg13g2_decap_8
XFILLER_16_407 VPWR VGND sg13g2_decap_8
XFILLER_44_749 VPWR VGND sg13g2_decap_8
XFILLER_43_259 VPWR VGND sg13g2_decap_8
XFILLER_12_613 VPWR VGND sg13g2_decap_8
XFILLER_25_963 VPWR VGND sg13g2_decap_8
XFILLER_24_473 VPWR VGND sg13g2_decap_8
XFILLER_11_134 VPWR VGND sg13g2_decap_8
XFILLER_8_617 VPWR VGND sg13g2_decap_8
XFILLER_7_127 VPWR VGND sg13g2_decap_8
XFILLER_22_74 VPWR VGND sg13g2_decap_8
XFILLER_20_690 VPWR VGND sg13g2_decap_8
XFILLER_4_834 VPWR VGND sg13g2_decap_8
XFILLER_3_344 VPWR VGND sg13g2_decap_8
XFILLER_26_1028 VPWR VGND sg13g2_fill_1
XFILLER_47_532 VPWR VGND sg13g2_decap_8
XFILLER_19_212 VPWR VGND sg13g2_decap_8
XdigitalL.g\[21\].u.inv VPWR digitalL.g\[21\].u.OUTN net81 VGND sg13g2_inv_1
XFILLER_35_738 VPWR VGND sg13g2_fill_1
XFILLER_19_289 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_117 VPWR VGND uio_oe[2] sg13g2_tiehi
XFILLER_34_259 VPWR VGND sg13g2_decap_8
XFILLER_15_484 VPWR VGND sg13g2_decap_8
XFILLER_30_410 VPWR VGND sg13g2_decap_8
XFILLER_8_43 VPWR VGND sg13g2_decap_8
XFILLER_31_999 VPWR VGND sg13g2_fill_1
XFILLER_30_487 VPWR VGND sg13g2_decap_8
XFILLER_7_694 VPWR VGND sg13g2_decap_8
XFILLER_38_532 VPWR VGND sg13g2_decap_8
X_19_ net115 net5 VPWR VGND sg13g2_buf_1
XdigitalL.g\[116\].u.inv VPWR digitalL.g\[116\].u.OUTN net78 VGND sg13g2_inv_1
XFILLER_22_900 VPWR VGND sg13g2_decap_8
XdigitalH.g\[66\].u.inv VPWR digitalH.g\[66\].u.OUTN net63 VGND sg13g2_inv_1
XFILLER_21_410 VPWR VGND sg13g2_decap_8
XdigitalH.g\[51\].u.buff net50 digitalH.g\[51\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_22_977 VPWR VGND sg13g2_decap_8
XFILLER_21_487 VPWR VGND sg13g2_decap_8
XFILLER_1_826 VPWR VGND sg13g2_decap_8
XFILLER_0_336 VPWR VGND sg13g2_decap_8
XFILLER_49_819 VPWR VGND sg13g2_decap_8
XFILLER_48_329 VPWR VGND sg13g2_decap_8
XFILLER_29_543 VPWR VGND sg13g2_decap_8
XFILLER_16_204 VPWR VGND sg13g2_decap_8
XFILLER_1_1008 VPWR VGND sg13g2_decap_8
XFILLER_44_546 VPWR VGND sg13g2_decap_8
XFILLER_17_85 VPWR VGND sg13g2_decap_8
XFILLER_31_207 VPWR VGND sg13g2_decap_8
XFILLER_25_760 VPWR VGND sg13g2_decap_8
XFILLER_12_410 VPWR VGND sg13g2_decap_8
XFILLER_24_270 VPWR VGND sg13g2_decap_8
XFILLER_12_487 VPWR VGND sg13g2_decap_8
XFILLER_8_414 VPWR VGND sg13g2_decap_8
XFILLER_33_84 VPWR VGND sg13g2_decap_8
XFILLER_4_631 VPWR VGND sg13g2_decap_8
XFILLER_3_141 VPWR VGND sg13g2_decap_8
XFILLER_39_329 VPWR VGND sg13g2_decap_8
XFILLER_48_896 VPWR VGND sg13g2_decap_8
XFILLER_35_546 VPWR VGND sg13g2_decap_8
XFILLER_22_207 VPWR VGND sg13g2_decap_8
XFILLER_15_281 VPWR VGND sg13g2_decap_8
XFILLER_30_284 VPWR VGND sg13g2_decap_8
XFILLER_7_491 VPWR VGND sg13g2_decap_8
XFILLER_14_708 VPWR VGND sg13g2_decap_8
XFILLER_26_557 VPWR VGND sg13g2_decap_8
XFILLER_13_218 VPWR VGND sg13g2_decap_8
XFILLER_22_774 VPWR VGND sg13g2_decap_8
XFILLER_21_284 VPWR VGND sg13g2_decap_8
XFILLER_5_428 VPWR VGND sg13g2_decap_8
XFILLER_1_623 VPWR VGND sg13g2_decap_8
XFILLER_0_133 VPWR VGND sg13g2_decap_8
XFILLER_49_616 VPWR VGND sg13g2_decap_8
XFILLER_48_126 VPWR VGND sg13g2_decap_8
XFILLER_29_340 VPWR VGND sg13g2_decap_8
XFILLER_45_833 VPWR VGND sg13g2_decap_8
XFILLER_28_95 VPWR VGND sg13g2_decap_8
XFILLER_17_568 VPWR VGND sg13g2_decap_8
XFILLER_44_343 VPWR VGND sg13g2_decap_8
XFILLER_9_701 VPWR VGND sg13g2_decap_8
XFILLER_8_211 VPWR VGND sg13g2_decap_8
XFILLER_40_560 VPWR VGND sg13g2_decap_8
XFILLER_12_284 VPWR VGND sg13g2_decap_8
XFILLER_8_288 VPWR VGND sg13g2_decap_8
XFILLER_5_22 VPWR VGND sg13g2_decap_8
XFILLER_5_995 VPWR VGND sg13g2_decap_8
XdigitalH.g\[14\].u.inv VPWR digitalH.g\[14\].u.OUTN net26 VGND sg13g2_inv_1
XFILLER_5_99 VPWR VGND sg13g2_decap_8
XFILLER_39_126 VPWR VGND sg13g2_decap_8
XFILLER_48_693 VPWR VGND sg13g2_decap_8
XFILLER_35_343 VPWR VGND sg13g2_decap_8
XFILLER_31_571 VPWR VGND sg13g2_decap_8
XFILLER_49_28 VPWR VGND sg13g2_decap_8
XFILLER_39_693 VPWR VGND sg13g2_decap_8
XFILLER_27_833 VPWR VGND sg13g2_decap_8
XFILLER_14_505 VPWR VGND sg13g2_decap_8
XFILLER_26_354 VPWR VGND sg13g2_decap_8
XdigitalL.g\[68\].u.inv VPWR digitalL.g\[68\].u.OUTN net111 VGND sg13g2_inv_1
XFILLER_42_858 VPWR VGND sg13g2_fill_1
XFILLER_41_357 VPWR VGND sg13g2_decap_8
XFILLER_22_571 VPWR VGND sg13g2_decap_8
XFILLER_14_64 VPWR VGND sg13g2_decap_8
XFILLER_6_715 VPWR VGND sg13g2_decap_8
XFILLER_5_225 VPWR VGND sg13g2_decap_8
XFILLER_30_74 VPWR VGND sg13g2_decap_8
XFILLER_2_932 VPWR VGND sg13g2_decap_8
XFILLER_1_420 VPWR VGND sg13g2_decap_8
XFILLER_7_1003 VPWR VGND sg13g2_fill_1
XFILLER_49_413 VPWR VGND sg13g2_decap_8
XFILLER_1_497 VPWR VGND sg13g2_decap_8
XFILLER_18_811 VPWR VGND sg13g2_fill_2
XFILLER_45_630 VPWR VGND sg13g2_decap_8
XFILLER_44_140 VPWR VGND sg13g2_decap_8
XFILLER_18_877 VPWR VGND sg13g2_fill_2
XFILLER_17_365 VPWR VGND sg13g2_decap_8
XFILLER_32_368 VPWR VGND sg13g2_decap_8
XFILLER_20_508 VPWR VGND sg13g2_decap_8
XFILLER_13_582 VPWR VGND sg13g2_decap_8
XFILLER_9_575 VPWR VGND sg13g2_decap_8
XdigitalL.g\[85\].u.buff net99 digitalL.g\[85\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_5_792 VPWR VGND sg13g2_decap_8
XdigitalL.g\[14\].u.buff net73 digitalL.g\[14\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[9\].u.buff net25 digitalH.g\[9\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_49_980 VPWR VGND sg13g2_decap_8
XFILLER_48_490 VPWR VGND sg13g2_decap_8
XFILLER_36_630 VPWR VGND sg13g2_decap_8
XdigitalH.g\[108\].u.buff net39 digitalH.g\[108\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_35_140 VPWR VGND sg13g2_decap_8
XFILLER_24_858 VPWR VGND sg13g2_decap_8
XFILLER_11_519 VPWR VGND sg13g2_decap_8
XFILLER_23_368 VPWR VGND sg13g2_decap_8
XFILLER_3_729 VPWR VGND sg13g2_decap_8
XFILLER_4_8 VPWR VGND sg13g2_decap_8
XFILLER_2_239 VPWR VGND sg13g2_decap_8
XFILLER_47_917 VPWR VGND sg13g2_decap_8
XFILLER_46_427 VPWR VGND sg13g2_decap_8
XFILLER_27_630 VPWR VGND sg13g2_decap_8
XFILLER_39_490 VPWR VGND sg13g2_decap_8
XFILLER_14_302 VPWR VGND sg13g2_decap_8
XFILLER_26_151 VPWR VGND sg13g2_decap_8
XFILLER_42_644 VPWR VGND sg13g2_decap_8
XFILLER_14_379 VPWR VGND sg13g2_decap_8
XFILLER_41_154 VPWR VGND sg13g2_decap_8
XFILLER_30_839 VPWR VGND sg13g2_fill_1
XFILLER_25_74 VPWR VGND sg13g2_decap_8
XFILLER_10_530 VPWR VGND sg13g2_decap_8
XFILLER_6_512 VPWR VGND sg13g2_decap_8
XFILLER_41_84 VPWR VGND sg13g2_decap_8
XFILLER_6_589 VPWR VGND sg13g2_decap_8
XdigitalL.g\[9\].u.inv VPWR digitalL.g\[9\].u.OUTN net72 VGND sg13g2_inv_1
XFILLER_29_1026 VPWR VGND sg13g2_fill_2
XFILLER_49_210 VPWR VGND sg13g2_decap_8
XFILLER_1_294 VPWR VGND sg13g2_decap_8
XFILLER_49_287 VPWR VGND sg13g2_decap_8
XFILLER_37_427 VPWR VGND sg13g2_decap_8
XFILLER_2_78 VPWR VGND sg13g2_decap_8
XFILLER_18_652 VPWR VGND sg13g2_decap_8
XFILLER_17_162 VPWR VGND sg13g2_decap_8
XFILLER_46_994 VPWR VGND sg13g2_decap_8
XFILLER_33_644 VPWR VGND sg13g2_decap_8
XFILLER_32_165 VPWR VGND sg13g2_decap_8
XFILLER_21_806 VPWR VGND sg13g2_decap_8
XFILLER_20_305 VPWR VGND sg13g2_decap_8
XFILLER_9_372 VPWR VGND sg13g2_decap_8
XdigitalH.g\[125\].u.inv VPWR digitalH.g\[125\].u.OUTN net22 VGND sg13g2_inv_1
XdigitalL.g\[16\].u.inv VPWR digitalL.g\[16\].u.OUTN net74 VGND sg13g2_inv_1
XdigitalH.g\[76\].u.buff net60 digitalH.g\[76\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_928 VPWR VGND sg13g2_decap_8
XFILLER_28_438 VPWR VGND sg13g2_decap_8
XFILLER_24_655 VPWR VGND sg13g2_decap_8
XFILLER_23_165 VPWR VGND sg13g2_decap_8
XFILLER_11_316 VPWR VGND sg13g2_decap_8
XFILLER_7_309 VPWR VGND sg13g2_decap_8
XFILLER_11_43 VPWR VGND sg13g2_decap_8
XFILLER_3_526 VPWR VGND sg13g2_decap_8
XFILLER_47_714 VPWR VGND sg13g2_decap_8
XFILLER_46_224 VPWR VGND sg13g2_decap_8
XFILLER_36_84 VPWR VGND sg13g2_decap_8
XFILLER_15_666 VPWR VGND sg13g2_decap_8
XFILLER_42_441 VPWR VGND sg13g2_decap_8
XFILLER_14_176 VPWR VGND sg13g2_decap_8
XFILLER_7_810 VPWR VGND sg13g2_fill_1
XFILLER_30_669 VPWR VGND sg13g2_decap_8
XFILLER_7_832 VPWR VGND sg13g2_decap_4
XFILLER_7_865 VPWR VGND sg13g2_decap_4
XFILLER_6_386 VPWR VGND sg13g2_decap_8
XFILLER_38_714 VPWR VGND sg13g2_decap_8
XFILLER_28_4 VPWR VGND sg13g2_decap_8
XFILLER_37_224 VPWR VGND sg13g2_decap_8
XFILLER_19_983 VPWR VGND sg13g2_fill_1
XFILLER_46_791 VPWR VGND sg13g2_decap_8
XFILLER_33_441 VPWR VGND sg13g2_decap_8
XFILLER_20_102 VPWR VGND sg13g2_decap_8
XFILLER_21_669 VPWR VGND sg13g2_decap_8
XFILLER_20_179 VPWR VGND sg13g2_decap_8
XdigitalL.g\[112\].u.inv VPWR digitalL.g\[112\].u.OUTN net80 VGND sg13g2_inv_1
XFILLER_0_518 VPWR VGND sg13g2_decap_8
XdigitalH.g\[62\].u.inv VPWR digitalH.g\[62\].u.OUTN net65 VGND sg13g2_inv_1
XdigitalH.g\[123\].u.buff net33 digitalH.g\[123\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_725 VPWR VGND sg13g2_decap_8
XFILLER_28_235 VPWR VGND sg13g2_decap_8
XFILLER_44_728 VPWR VGND sg13g2_decap_8
XFILLER_43_238 VPWR VGND sg13g2_decap_8
XFILLER_25_942 VPWR VGND sg13g2_decap_8
XFILLER_24_452 VPWR VGND sg13g2_decap_8
XFILLER_11_113 VPWR VGND sg13g2_decap_8
XFILLER_12_669 VPWR VGND sg13g2_decap_8
XFILLER_7_106 VPWR VGND sg13g2_decap_8
XFILLER_22_53 VPWR VGND sg13g2_decap_8
XFILLER_4_813 VPWR VGND sg13g2_decap_8
XFILLER_3_323 VPWR VGND sg13g2_decap_8
XFILLER_47_511 VPWR VGND sg13g2_decap_8
XFILLER_47_588 VPWR VGND sg13g2_decap_8
XFILLER_19_268 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_118 VPWR VGND uio_oe[3] sg13g2_tiehi
XFILLER_34_238 VPWR VGND sg13g2_decap_8
XFILLER_15_463 VPWR VGND sg13g2_decap_8
XFILLER_8_22 VPWR VGND sg13g2_decap_8
XFILLER_30_466 VPWR VGND sg13g2_decap_8
XFILLER_11_680 VPWR VGND sg13g2_decap_8
XFILLER_8_99 VPWR VGND sg13g2_decap_8
XFILLER_7_673 VPWR VGND sg13g2_decap_8
XFILLER_6_183 VPWR VGND sg13g2_decap_8
XFILLER_3_890 VPWR VGND sg13g2_decap_8
XFILLER_38_511 VPWR VGND sg13g2_decap_8
X_18_ net68 net20 VPWR VGND sg13g2_buf_1
XFILLER_38_588 VPWR VGND sg13g2_decap_8
XFILLER_26_739 VPWR VGND sg13g2_decap_8
XFILLER_25_249 VPWR VGND sg13g2_decap_8
XdigitalL.g\[113\].u.buff net78 digitalL.g\[113\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_22_956 VPWR VGND sg13g2_decap_8
XFILLER_21_466 VPWR VGND sg13g2_decap_8
XdigitalH.g\[91\].u.buff net55 digitalH.g\[91\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[20\].u.buff net28 digitalH.g\[20\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_1_805 VPWR VGND sg13g2_decap_8
XFILLER_0_315 VPWR VGND sg13g2_decap_8
XFILLER_48_308 VPWR VGND sg13g2_decap_8
XFILLER_29_522 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[3\].u.buff net3 digitalenL.g\[3\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_17_64 VPWR VGND sg13g2_decap_8
XFILLER_44_525 VPWR VGND sg13g2_decap_8
XFILLER_29_599 VPWR VGND sg13g2_decap_8
XFILLER_12_466 VPWR VGND sg13g2_decap_8
XFILLER_33_63 VPWR VGND sg13g2_decap_8
XFILLER_4_610 VPWR VGND sg13g2_decap_8
XFILLER_3_120 VPWR VGND sg13g2_decap_8
XFILLER_4_687 VPWR VGND sg13g2_decap_8
XFILLER_3_197 VPWR VGND sg13g2_decap_8
XFILLER_39_308 VPWR VGND sg13g2_decap_8
XFILLER_0_882 VPWR VGND sg13g2_decap_8
XFILLER_48_875 VPWR VGND sg13g2_decap_8
XdigitalL.g\[39\].u.buff net93 digitalL.g\[39\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_385 VPWR VGND sg13g2_decap_8
XFILLER_35_525 VPWR VGND sg13g2_decap_8
XFILLER_15_260 VPWR VGND sg13g2_decap_8
XdigitalH.g\[10\].u.inv VPWR digitalH.g\[10\].u.OUTN net24 VGND sg13g2_inv_1
XdigitalL.g\[4\].u.buff net71 digitalL.g\[4\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_31_753 VPWR VGND sg13g2_decap_8
XFILLER_30_263 VPWR VGND sg13g2_decap_8
XFILLER_7_470 VPWR VGND sg13g2_decap_8
XFILLER_38_385 VPWR VGND sg13g2_decap_8
XFILLER_26_536 VPWR VGND sg13g2_decap_8
XFILLER_41_539 VPWR VGND sg13g2_decap_8
XFILLER_22_753 VPWR VGND sg13g2_decap_8
XFILLER_21_263 VPWR VGND sg13g2_decap_8
XFILLER_6_908 VPWR VGND sg13g2_decap_8
XFILLER_5_407 VPWR VGND sg13g2_decap_8
XdigitalL.g\[64\].u.inv VPWR digitalL.g\[64\].u.OUTN net109 VGND sg13g2_inv_1
XFILLER_1_602 VPWR VGND sg13g2_decap_8
XFILLER_0_112 VPWR VGND sg13g2_decap_8
XFILLER_48_105 VPWR VGND sg13g2_decap_8
XFILLER_1_679 VPWR VGND sg13g2_decap_8
XFILLER_0_189 VPWR VGND sg13g2_decap_8
XFILLER_45_812 VPWR VGND sg13g2_decap_8
XFILLER_28_74 VPWR VGND sg13g2_decap_8
XFILLER_17_547 VPWR VGND sg13g2_decap_8
XFILLER_44_322 VPWR VGND sg13g2_decap_8
XFILLER_29_396 VPWR VGND sg13g2_decap_8
XFILLER_45_889 VPWR VGND sg13g2_decap_8
XFILLER_44_399 VPWR VGND sg13g2_decap_8
XFILLER_44_84 VPWR VGND sg13g2_decap_8
XFILLER_12_263 VPWR VGND sg13g2_decap_8
XFILLER_8_267 VPWR VGND sg13g2_decap_8
XFILLER_5_974 VPWR VGND sg13g2_decap_8
XFILLER_4_484 VPWR VGND sg13g2_decap_8
XFILLER_5_78 VPWR VGND sg13g2_decap_8
XFILLER_39_105 VPWR VGND sg13g2_decap_8
XFILLER_48_672 VPWR VGND sg13g2_decap_8
XFILLER_47_182 VPWR VGND sg13g2_decap_8
XFILLER_35_322 VPWR VGND sg13g2_decap_8
XFILLER_35_399 VPWR VGND sg13g2_decap_8
XFILLER_31_550 VPWR VGND sg13g2_decap_8
XFILLER_46_609 VPWR VGND sg13g2_decap_8
XFILLER_39_672 VPWR VGND sg13g2_decap_8
XFILLER_27_812 VPWR VGND sg13g2_decap_8
XFILLER_45_119 VPWR VGND sg13g2_decap_8
XFILLER_38_182 VPWR VGND sg13g2_decap_8
XFILLER_26_333 VPWR VGND sg13g2_decap_8
XFILLER_27_889 VPWR VGND sg13g2_decap_8
XFILLER_41_336 VPWR VGND sg13g2_decap_8
XFILLER_14_43 VPWR VGND sg13g2_decap_8
XFILLER_22_550 VPWR VGND sg13g2_decap_8
XFILLER_10_712 VPWR VGND sg13g2_decap_8
XFILLER_5_204 VPWR VGND sg13g2_decap_8
XFILLER_30_53 VPWR VGND sg13g2_decap_8
XFILLER_2_911 VPWR VGND sg13g2_decap_8
XFILLER_2_988 VPWR VGND sg13g2_decap_8
XFILLER_1_476 VPWR VGND sg13g2_decap_8
XFILLER_39_84 VPWR VGND sg13g2_decap_8
XFILLER_49_469 VPWR VGND sg13g2_decap_8
XFILLER_37_609 VPWR VGND sg13g2_decap_8
XFILLER_36_119 VPWR VGND sg13g2_decap_8
XFILLER_18_823 VPWR VGND sg13g2_fill_1
XFILLER_17_344 VPWR VGND sg13g2_decap_8
XFILLER_29_193 VPWR VGND sg13g2_decap_8
XdigitalL.g\[5\].u.inv VPWR digitalL.g\[5\].u.OUTN net71 VGND sg13g2_inv_1
XFILLER_45_686 VPWR VGND sg13g2_decap_8
XFILLER_44_196 VPWR VGND sg13g2_decap_8
XFILLER_32_347 VPWR VGND sg13g2_decap_8
XFILLER_13_561 VPWR VGND sg13g2_decap_8
XFILLER_9_554 VPWR VGND sg13g2_decap_8
XFILLER_5_771 VPWR VGND sg13g2_decap_8
XFILLER_4_281 VPWR VGND sg13g2_decap_8
XdigitalL.g\[54\].u.buff net103 digitalL.g\[54\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_27_119 VPWR VGND sg13g2_decap_8
XdigitalH.g\[121\].u.inv VPWR digitalH.g\[121\].u.OUTN net33 VGND sg13g2_inv_1
XdigitalL.g\[12\].u.inv VPWR digitalL.g\[12\].u.OUTN net73 VGND sg13g2_inv_1
XFILLER_36_686 VPWR VGND sg13g2_decap_8
XFILLER_24_837 VPWR VGND sg13g2_decap_8
XFILLER_35_196 VPWR VGND sg13g2_decap_8
XFILLER_23_347 VPWR VGND sg13g2_decap_8
XFILLER_32_870 VPWR VGND sg13g2_fill_2
XFILLER_3_708 VPWR VGND sg13g2_decap_8
XFILLER_2_218 VPWR VGND sg13g2_decap_8
XFILLER_46_406 VPWR VGND sg13g2_decap_8
XdigitalL.g\[107\].u.inv VPWR digitalL.g\[107\].u.OUTN net86 VGND sg13g2_inv_1
XFILLER_26_130 VPWR VGND sg13g2_decap_8
XFILLER_27_686 VPWR VGND sg13g2_decap_8
XFILLER_42_623 VPWR VGND sg13g2_decap_8
XFILLER_25_53 VPWR VGND sg13g2_decap_8
XFILLER_14_358 VPWR VGND sg13g2_decap_8
XdigitalH.g\[57\].u.inv VPWR digitalH.g\[57\].u.OUTN net52 VGND sg13g2_inv_1
XFILLER_41_133 VPWR VGND sg13g2_decap_8
XFILLER_30_818 VPWR VGND sg13g2_decap_4
XFILLER_30_807 VPWR VGND sg13g2_decap_8
XFILLER_10_586 VPWR VGND sg13g2_decap_8
XFILLER_41_63 VPWR VGND sg13g2_decap_8
XFILLER_6_568 VPWR VGND sg13g2_decap_8
XFILLER_29_1005 VPWR VGND sg13g2_decap_8
XFILLER_2_785 VPWR VGND sg13g2_decap_8
XFILLER_1_273 VPWR VGND sg13g2_decap_8
XFILLER_49_266 VPWR VGND sg13g2_decap_8
XFILLER_37_406 VPWR VGND sg13g2_decap_8
XFILLER_2_57 VPWR VGND sg13g2_decap_8
XFILLER_18_631 VPWR VGND sg13g2_decap_8
XFILLER_17_141 VPWR VGND sg13g2_decap_8
XFILLER_46_973 VPWR VGND sg13g2_decap_8
XFILLER_45_483 VPWR VGND sg13g2_decap_8
XFILLER_33_623 VPWR VGND sg13g2_decap_8
XFILLER_32_144 VPWR VGND sg13g2_decap_8
XFILLER_9_351 VPWR VGND sg13g2_decap_8
XFILLER_49_0 VPWR VGND sg13g2_decap_8
XFILLER_29_907 VPWR VGND sg13g2_decap_8
XdigitalH.g\[45\].u.buff net49 digitalH.g\[45\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_28_417 VPWR VGND sg13g2_decap_8
XFILLER_36_483 VPWR VGND sg13g2_decap_8
XFILLER_24_634 VPWR VGND sg13g2_decap_8
XFILLER_23_144 VPWR VGND sg13g2_decap_8
XFILLER_20_840 VPWR VGND sg13g2_fill_2
XFILLER_11_22 VPWR VGND sg13g2_decap_8
XFILLER_3_505 VPWR VGND sg13g2_decap_8
XFILLER_11_99 VPWR VGND sg13g2_decap_8
XFILLER_46_203 VPWR VGND sg13g2_decap_8
XFILLER_36_63 VPWR VGND sg13g2_decap_8
XFILLER_28_984 VPWR VGND sg13g2_decap_8
XFILLER_15_645 VPWR VGND sg13g2_decap_8
XFILLER_42_420 VPWR VGND sg13g2_decap_8
XFILLER_27_483 VPWR VGND sg13g2_decap_8
XFILLER_14_155 VPWR VGND sg13g2_decap_8
XFILLER_42_497 VPWR VGND sg13g2_decap_8
XFILLER_30_648 VPWR VGND sg13g2_decap_8
XFILLER_10_383 VPWR VGND sg13g2_decap_8
XFILLER_6_365 VPWR VGND sg13g2_decap_8
XFILLER_42_7 VPWR VGND sg13g2_decap_8
XFILLER_2_582 VPWR VGND sg13g2_decap_8
XFILLER_37_203 VPWR VGND sg13g2_decap_8
XFILLER_46_770 VPWR VGND sg13g2_decap_8
XFILLER_45_280 VPWR VGND sg13g2_decap_8
XFILLER_33_420 VPWR VGND sg13g2_decap_8
XFILLER_33_497 VPWR VGND sg13g2_decap_8
XFILLER_21_648 VPWR VGND sg13g2_decap_8
XFILLER_20_158 VPWR VGND sg13g2_decap_8
XFILLER_29_704 VPWR VGND sg13g2_decap_8
XFILLER_28_214 VPWR VGND sg13g2_decap_8
XFILLER_44_707 VPWR VGND sg13g2_decap_8
XFILLER_43_217 VPWR VGND sg13g2_decap_8
XFILLER_36_280 VPWR VGND sg13g2_decap_8
XFILLER_25_921 VPWR VGND sg13g2_decap_8
XFILLER_24_431 VPWR VGND sg13g2_decap_8
XFILLER_25_998 VPWR VGND sg13g2_decap_8
XFILLER_12_648 VPWR VGND sg13g2_decap_8
XFILLER_11_169 VPWR VGND sg13g2_decap_8
XFILLER_22_32 VPWR VGND sg13g2_decap_8
XFILLER_3_302 VPWR VGND sg13g2_decap_8
XFILLER_4_869 VPWR VGND sg13g2_decap_8
XFILLER_3_379 VPWR VGND sg13g2_decap_8
XFILLER_26_1019 VPWR VGND sg13g2_decap_8
XFILLER_19_247 VPWR VGND sg13g2_decap_8
XFILLER_47_84 VPWR VGND sg13g2_decap_8
XFILLER_47_567 VPWR VGND sg13g2_decap_8
XFILLER_35_707 VPWR VGND sg13g2_decap_8
XFILLER_34_217 VPWR VGND sg13g2_decap_8
XFILLER_28_781 VPWR VGND sg13g2_decap_8
XFILLER_27_280 VPWR VGND sg13g2_decap_8
XFILLER_15_442 VPWR VGND sg13g2_decap_8
Xheichips25_pudding_119 VPWR VGND uio_oe[4] sg13g2_tiehi
XdigitalL.g\[59\].u.inv VPWR digitalL.g\[59\].u.OUTN net104 VGND sg13g2_inv_1
XFILLER_43_773 VPWR VGND sg13g2_fill_1
XFILLER_42_294 VPWR VGND sg13g2_decap_8
XFILLER_31_957 VPWR VGND sg13g2_fill_1
XFILLER_30_445 VPWR VGND sg13g2_decap_8
XFILLER_7_652 VPWR VGND sg13g2_decap_8
XFILLER_8_78 VPWR VGND sg13g2_decap_8
XFILLER_10_180 VPWR VGND sg13g2_decap_8
XFILLER_6_162 VPWR VGND sg13g2_decap_8
X_17_ net68 net19 VPWR VGND sg13g2_buf_1
XFILLER_38_567 VPWR VGND sg13g2_decap_8
XFILLER_26_718 VPWR VGND sg13g2_decap_8
XFILLER_25_228 VPWR VGND sg13g2_decap_8
XFILLER_22_935 VPWR VGND sg13g2_decap_8
XFILLER_33_294 VPWR VGND sg13g2_decap_8
XFILLER_21_445 VPWR VGND sg13g2_decap_8
XFILLER_49_1008 VPWR VGND sg13g2_decap_8
XdigitalH.g\[60\].u.buff net52 digitalH.g\[60\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_501 VPWR VGND sg13g2_decap_8
XFILLER_17_729 VPWR VGND sg13g2_decap_8
XFILLER_44_504 VPWR VGND sg13g2_decap_8
XFILLER_29_578 VPWR VGND sg13g2_decap_8
XFILLER_16_239 VPWR VGND sg13g2_decap_8
XFILLER_17_43 VPWR VGND sg13g2_decap_8
XdigitalL.g\[60\].u.inv VPWR digitalL.g\[60\].u.OUTN net105 VGND sg13g2_inv_1
XFILLER_40_721 VPWR VGND sg13g2_decap_8
XFILLER_25_795 VPWR VGND sg13g2_decap_8
XFILLER_12_445 VPWR VGND sg13g2_decap_8
XFILLER_33_42 VPWR VGND sg13g2_decap_8
XFILLER_8_449 VPWR VGND sg13g2_decap_8
XFILLER_21_990 VPWR VGND sg13g2_decap_8
XFILLER_4_666 VPWR VGND sg13g2_decap_8
XFILLER_3_176 VPWR VGND sg13g2_decap_8
XFILLER_0_861 VPWR VGND sg13g2_decap_8
XFILLER_48_854 VPWR VGND sg13g2_decap_8
XFILLER_47_364 VPWR VGND sg13g2_decap_8
XFILLER_35_504 VPWR VGND sg13g2_decap_8
XdigitalL.g\[79\].u.buff net100 digitalL.g\[79\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_581 VPWR VGND sg13g2_decap_8
XFILLER_31_732 VPWR VGND sg13g2_decap_8
XFILLER_30_242 VPWR VGND sg13g2_decap_8
XFILLER_38_364 VPWR VGND sg13g2_decap_8
XFILLER_26_515 VPWR VGND sg13g2_decap_8
XFILLER_41_518 VPWR VGND sg13g2_decap_8
XFILLER_34_581 VPWR VGND sg13g2_decap_8
XFILLER_22_732 VPWR VGND sg13g2_decap_8
XFILLER_21_242 VPWR VGND sg13g2_decap_8
XdigitalH.g\[116\].u.inv VPWR digitalH.g\[116\].u.OUTN net36 VGND sg13g2_inv_1
XFILLER_1_658 VPWR VGND sg13g2_decap_8
XFILLER_0_168 VPWR VGND sg13g2_decap_8
XFILLER_28_53 VPWR VGND sg13g2_decap_8
XFILLER_17_526 VPWR VGND sg13g2_decap_8
XFILLER_44_301 VPWR VGND sg13g2_decap_8
XFILLER_29_375 VPWR VGND sg13g2_decap_8
XFILLER_45_868 VPWR VGND sg13g2_decap_8
XFILLER_44_378 VPWR VGND sg13g2_decap_8
XFILLER_32_529 VPWR VGND sg13g2_decap_8
XFILLER_44_63 VPWR VGND sg13g2_decap_8
XFILLER_25_592 VPWR VGND sg13g2_decap_8
XFILLER_12_242 VPWR VGND sg13g2_decap_8
XFILLER_8_246 VPWR VGND sg13g2_decap_8
XFILLER_40_595 VPWR VGND sg13g2_decap_8
XFILLER_5_953 VPWR VGND sg13g2_decap_8
XFILLER_4_463 VPWR VGND sg13g2_decap_8
XFILLER_5_57 VPWR VGND sg13g2_decap_8
XdigitalL.g\[1\].u.inv VPWR digitalL.g\[1\].u.OUTN net70 VGND sg13g2_inv_1
XFILLER_48_651 VPWR VGND sg13g2_decap_8
XFILLER_47_161 VPWR VGND sg13g2_decap_8
XFILLER_35_301 VPWR VGND sg13g2_decap_8
XFILLER_35_378 VPWR VGND sg13g2_decap_8
XFILLER_23_529 VPWR VGND sg13g2_decap_8
XFILLER_39_651 VPWR VGND sg13g2_decap_8
XFILLER_38_161 VPWR VGND sg13g2_decap_8
XFILLER_26_312 VPWR VGND sg13g2_decap_8
XFILLER_27_868 VPWR VGND sg13g2_decap_8
XFILLER_41_315 VPWR VGND sg13g2_decap_8
XFILLER_26_389 VPWR VGND sg13g2_decap_8
XFILLER_14_22 VPWR VGND sg13g2_decap_8
XFILLER_10_735 VPWR VGND sg13g2_decap_4
XFILLER_14_99 VPWR VGND sg13g2_decap_8
XFILLER_30_32 VPWR VGND sg13g2_decap_8
XdigitalL.g\[103\].u.inv VPWR digitalL.g\[103\].u.OUTN net87 VGND sg13g2_inv_1
XFILLER_2_967 VPWR VGND sg13g2_decap_8
XdigitalH.g\[53\].u.inv VPWR digitalH.g\[53\].u.OUTN net51 VGND sg13g2_inv_1
XFILLER_1_455 VPWR VGND sg13g2_decap_8
XFILLER_49_448 VPWR VGND sg13g2_decap_8
XFILLER_39_63 VPWR VGND sg13g2_decap_8
XFILLER_18_802 VPWR VGND sg13g2_fill_1
XFILLER_29_172 VPWR VGND sg13g2_decap_8
XFILLER_17_323 VPWR VGND sg13g2_decap_8
XFILLER_45_665 VPWR VGND sg13g2_decap_8
XFILLER_44_175 VPWR VGND sg13g2_decap_8
XFILLER_32_326 VPWR VGND sg13g2_decap_8
XFILLER_13_540 VPWR VGND sg13g2_decap_8
XFILLER_9_533 VPWR VGND sg13g2_decap_8
XFILLER_40_392 VPWR VGND sg13g2_decap_8
XFILLER_5_750 VPWR VGND sg13g2_decap_8
XFILLER_4_260 VPWR VGND sg13g2_decap_8
XFILLER_45_1022 VPWR VGND sg13g2_decap_8
XdigitalL.g\[94\].u.buff net89 digitalL.g\[94\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[23\].u.buff net82 digitalL.g\[23\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_665 VPWR VGND sg13g2_decap_8
XFILLER_24_816 VPWR VGND sg13g2_decap_8
XFILLER_35_175 VPWR VGND sg13g2_decap_8
XFILLER_23_326 VPWR VGND sg13g2_decap_8
XdigitalH.g\[117\].u.buff net33 digitalH.g\[117\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_42_602 VPWR VGND sg13g2_decap_8
XFILLER_27_665 VPWR VGND sg13g2_decap_8
XFILLER_14_337 VPWR VGND sg13g2_decap_8
XFILLER_41_112 VPWR VGND sg13g2_decap_8
XFILLER_26_186 VPWR VGND sg13g2_decap_8
XFILLER_25_32 VPWR VGND sg13g2_decap_8
XFILLER_42_679 VPWR VGND sg13g2_decap_8
XFILLER_41_189 VPWR VGND sg13g2_decap_8
XFILLER_23_893 VPWR VGND sg13g2_decap_8
XFILLER_10_565 VPWR VGND sg13g2_decap_8
XFILLER_41_42 VPWR VGND sg13g2_decap_8
XFILLER_6_547 VPWR VGND sg13g2_decap_8
XFILLER_29_1028 VPWR VGND sg13g2_fill_1
XFILLER_2_764 VPWR VGND sg13g2_decap_8
XFILLER_1_252 VPWR VGND sg13g2_decap_8
XFILLER_49_245 VPWR VGND sg13g2_decap_8
XFILLER_2_36 VPWR VGND sg13g2_decap_8
XFILLER_18_610 VPWR VGND sg13g2_decap_8
XFILLER_17_120 VPWR VGND sg13g2_decap_8
XFILLER_46_952 VPWR VGND sg13g2_decap_8
XFILLER_45_462 VPWR VGND sg13g2_decap_8
XFILLER_33_602 VPWR VGND sg13g2_decap_8
XFILLER_18_687 VPWR VGND sg13g2_decap_8
XFILLER_17_197 VPWR VGND sg13g2_decap_8
XFILLER_32_123 VPWR VGND sg13g2_decap_8
XFILLER_33_679 VPWR VGND sg13g2_decap_8
XFILLER_9_330 VPWR VGND sg13g2_decap_8
XdigitalL.g\[107\].u.buff net86 digitalL.g\[107\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_462 VPWR VGND sg13g2_decap_8
XdigitalH.g\[85\].u.buff net57 digitalH.g\[85\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_24_613 VPWR VGND sg13g2_decap_8
XdigitalH.g\[14\].u.buff net26 digitalH.g\[14\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_23_123 VPWR VGND sg13g2_decap_8
XFILLER_32_690 VPWR VGND sg13g2_decap_8
XFILLER_20_874 VPWR VGND sg13g2_fill_2
XFILLER_20_863 VPWR VGND sg13g2_decap_8
XFILLER_11_78 VPWR VGND sg13g2_decap_8
XFILLER_19_429 VPWR VGND sg13g2_decap_8
XFILLER_47_749 VPWR VGND sg13g2_decap_8
XFILLER_46_259 VPWR VGND sg13g2_decap_8
XFILLER_36_42 VPWR VGND sg13g2_decap_8
XFILLER_28_963 VPWR VGND sg13g2_decap_8
XFILLER_27_462 VPWR VGND sg13g2_decap_8
XFILLER_15_624 VPWR VGND sg13g2_decap_8
XFILLER_14_134 VPWR VGND sg13g2_decap_8
XFILLER_42_476 VPWR VGND sg13g2_decap_8
XFILLER_30_627 VPWR VGND sg13g2_decap_8
XFILLER_23_690 VPWR VGND sg13g2_decap_8
XFILLER_10_362 VPWR VGND sg13g2_decap_8
XFILLER_7_823 VPWR VGND sg13g2_fill_1
XFILLER_6_344 VPWR VGND sg13g2_decap_8
XdigitalL.g\[55\].u.inv VPWR digitalL.g\[55\].u.OUTN net103 VGND sg13g2_inv_1
XFILLER_35_7 VPWR VGND sg13g2_decap_8
XFILLER_2_561 VPWR VGND sg13g2_decap_8
XFILLER_37_259 VPWR VGND sg13g2_decap_8
XFILLER_19_974 VPWR VGND sg13g2_fill_1
XFILLER_18_484 VPWR VGND sg13g2_decap_8
XFILLER_33_476 VPWR VGND sg13g2_decap_8
XFILLER_21_627 VPWR VGND sg13g2_decap_8
XFILLER_20_137 VPWR VGND sg13g2_decap_8
XFILLER_25_900 VPWR VGND sg13g2_decap_8
XFILLER_24_410 VPWR VGND sg13g2_decap_8
XFILLER_25_977 VPWR VGND sg13g2_decap_8
XFILLER_19_1027 VPWR VGND sg13g2_fill_2
XFILLER_12_627 VPWR VGND sg13g2_decap_8
XFILLER_24_487 VPWR VGND sg13g2_decap_8
XFILLER_11_148 VPWR VGND sg13g2_decap_8
XFILLER_22_11 VPWR VGND sg13g2_decap_8
XFILLER_22_88 VPWR VGND sg13g2_decap_8
XFILLER_4_848 VPWR VGND sg13g2_decap_8
XFILLER_3_358 VPWR VGND sg13g2_decap_8
XFILLER_47_63 VPWR VGND sg13g2_decap_8
XFILLER_47_546 VPWR VGND sg13g2_decap_8
XFILLER_19_226 VPWR VGND sg13g2_decap_8
XFILLER_28_760 VPWR VGND sg13g2_decap_8
XFILLER_15_421 VPWR VGND sg13g2_decap_8
XFILLER_42_273 VPWR VGND sg13g2_decap_8
XFILLER_15_498 VPWR VGND sg13g2_decap_8
XFILLER_30_424 VPWR VGND sg13g2_decap_8
XFILLER_8_57 VPWR VGND sg13g2_decap_8
XFILLER_7_631 VPWR VGND sg13g2_decap_8
XFILLER_6_141 VPWR VGND sg13g2_decap_8
XFILLER_38_546 VPWR VGND sg13g2_decap_8
X_16_ net68 net18 VPWR VGND sg13g2_buf_1
XFILLER_19_760 VPWR VGND sg13g2_fill_1
XFILLER_25_207 VPWR VGND sg13g2_decap_8
XFILLER_19_782 VPWR VGND sg13g2_fill_1
XFILLER_18_281 VPWR VGND sg13g2_decap_8
XFILLER_22_914 VPWR VGND sg13g2_decap_8
XFILLER_33_273 VPWR VGND sg13g2_decap_8
XFILLER_21_424 VPWR VGND sg13g2_decap_8
XFILLER_30_991 VPWR VGND sg13g2_decap_8
XdigitalL.g\[122\].u.buff net76 digitalL.g\[122\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_17_22 VPWR VGND sg13g2_decap_8
XFILLER_17_708 VPWR VGND sg13g2_decap_8
XFILLER_17_719 VPWR VGND sg13g2_fill_2
XFILLER_29_557 VPWR VGND sg13g2_decap_8
XFILLER_16_218 VPWR VGND sg13g2_decap_8
XdigitalH.g\[112\].u.inv VPWR digitalH.g\[112\].u.OUTN net37 VGND sg13g2_inv_1
XFILLER_17_99 VPWR VGND sg13g2_decap_8
XFILLER_40_700 VPWR VGND sg13g2_decap_8
XFILLER_25_774 VPWR VGND sg13g2_decap_8
XFILLER_12_424 VPWR VGND sg13g2_decap_8
XFILLER_33_21 VPWR VGND sg13g2_decap_8
XFILLER_24_284 VPWR VGND sg13g2_decap_8
XFILLER_8_428 VPWR VGND sg13g2_decap_8
XFILLER_33_98 VPWR VGND sg13g2_decap_8
XFILLER_4_645 VPWR VGND sg13g2_decap_8
XFILLER_3_155 VPWR VGND sg13g2_decap_8
XFILLER_0_840 VPWR VGND sg13g2_decap_8
XFILLER_48_833 VPWR VGND sg13g2_decap_8
XFILLER_47_343 VPWR VGND sg13g2_decap_8
XFILLER_43_560 VPWR VGND sg13g2_decap_8
XFILLER_31_711 VPWR VGND sg13g2_decap_8
XFILLER_15_295 VPWR VGND sg13g2_decap_8
XdigitalH.g\[48\].u.inv VPWR digitalH.g\[48\].u.OUTN net50 VGND sg13g2_inv_1
XFILLER_30_221 VPWR VGND sg13g2_decap_8
XFILLER_30_298 VPWR VGND sg13g2_decap_8
XFILLER_8_984 VPWR VGND sg13g2_fill_1
XdigitalL.g\[48\].u.buff net95 digitalL.g\[48\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_343 VPWR VGND sg13g2_decap_8
XFILLER_0_1022 VPWR VGND sg13g2_decap_8
XFILLER_19_590 VPWR VGND sg13g2_decap_8
XFILLER_0_91 VPWR VGND sg13g2_decap_8
XFILLER_34_560 VPWR VGND sg13g2_decap_8
XFILLER_22_711 VPWR VGND sg13g2_decap_8
XFILLER_21_221 VPWR VGND sg13g2_decap_8
XFILLER_22_788 VPWR VGND sg13g2_decap_8
XFILLER_21_298 VPWR VGND sg13g2_decap_8
XFILLER_1_637 VPWR VGND sg13g2_decap_8
XFILLER_0_147 VPWR VGND sg13g2_decap_8
XFILLER_28_32 VPWR VGND sg13g2_decap_8
XFILLER_29_354 VPWR VGND sg13g2_decap_8
XFILLER_17_505 VPWR VGND sg13g2_decap_8
XFILLER_45_847 VPWR VGND sg13g2_decap_8
XFILLER_44_357 VPWR VGND sg13g2_decap_8
XFILLER_44_42 VPWR VGND sg13g2_decap_8
XFILLER_32_508 VPWR VGND sg13g2_decap_8
XFILLER_12_221 VPWR VGND sg13g2_decap_8
XFILLER_13_722 VPWR VGND sg13g2_decap_8
XFILLER_25_571 VPWR VGND sg13g2_decap_8
XFILLER_9_715 VPWR VGND sg13g2_decap_8
XFILLER_8_225 VPWR VGND sg13g2_decap_8
XFILLER_40_574 VPWR VGND sg13g2_decap_8
XFILLER_12_298 VPWR VGND sg13g2_decap_8
XFILLER_5_932 VPWR VGND sg13g2_decap_8
XFILLER_4_442 VPWR VGND sg13g2_decap_8
XFILLER_5_36 VPWR VGND sg13g2_decap_8
XFILLER_48_630 VPWR VGND sg13g2_decap_8
XFILLER_47_140 VPWR VGND sg13g2_decap_8
XFILLER_35_357 VPWR VGND sg13g2_decap_8
XFILLER_23_508 VPWR VGND sg13g2_decap_8
XFILLER_16_582 VPWR VGND sg13g2_decap_8
XFILLER_31_585 VPWR VGND sg13g2_decap_8
XdigitalH.g\[39\].u.buff net45 digitalH.g\[39\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_630 VPWR VGND sg13g2_decap_8
XFILLER_22_1012 VPWR VGND sg13g2_decap_8
XFILLER_38_140 VPWR VGND sg13g2_decap_8
XFILLER_27_847 VPWR VGND sg13g2_decap_8
XFILLER_14_519 VPWR VGND sg13g2_decap_8
XFILLER_26_368 VPWR VGND sg13g2_decap_8
XFILLER_14_78 VPWR VGND sg13g2_decap_8
XFILLER_22_585 VPWR VGND sg13g2_decap_8
XFILLER_6_729 VPWR VGND sg13g2_decap_8
XFILLER_30_11 VPWR VGND sg13g2_decap_8
XFILLER_5_239 VPWR VGND sg13g2_decap_8
XFILLER_30_88 VPWR VGND sg13g2_decap_8
XFILLER_2_946 VPWR VGND sg13g2_decap_8
XFILLER_1_434 VPWR VGND sg13g2_decap_8
XFILLER_7_1017 VPWR VGND sg13g2_decap_8
XFILLER_39_42 VPWR VGND sg13g2_decap_8
XFILLER_7_1028 VPWR VGND sg13g2_fill_1
XFILLER_49_427 VPWR VGND sg13g2_decap_8
XFILLER_17_302 VPWR VGND sg13g2_decap_8
XFILLER_29_151 VPWR VGND sg13g2_decap_8
XFILLER_45_644 VPWR VGND sg13g2_decap_8
XFILLER_18_869 VPWR VGND sg13g2_fill_1
XFILLER_17_379 VPWR VGND sg13g2_decap_8
XFILLER_44_154 VPWR VGND sg13g2_decap_8
XFILLER_32_305 VPWR VGND sg13g2_decap_8
XFILLER_9_512 VPWR VGND sg13g2_decap_8
XFILLER_40_371 VPWR VGND sg13g2_decap_8
XFILLER_13_596 VPWR VGND sg13g2_decap_8
XFILLER_9_589 VPWR VGND sg13g2_decap_8
XFILLER_45_1001 VPWR VGND sg13g2_decap_8
XFILLER_49_994 VPWR VGND sg13g2_decap_8
XFILLER_36_644 VPWR VGND sg13g2_decap_8
XFILLER_35_154 VPWR VGND sg13g2_decap_8
XFILLER_23_305 VPWR VGND sg13g2_decap_8
XdigitalL.g\[63\].u.buff net105 digitalL.g\[63\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_32_883 VPWR VGND sg13g2_fill_1
XFILLER_31_382 VPWR VGND sg13g2_decap_8
XFILLER_27_644 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[3\].u.inv VPWR digitalenH.g\[3\].u.OUTN net4 VGND sg13g2_inv_1
XFILLER_25_11 VPWR VGND sg13g2_decap_8
XFILLER_14_316 VPWR VGND sg13g2_decap_8
XFILLER_26_165 VPWR VGND sg13g2_decap_8
XFILLER_42_658 VPWR VGND sg13g2_decap_8
XFILLER_25_88 VPWR VGND sg13g2_decap_8
XFILLER_41_168 VPWR VGND sg13g2_decap_8
XFILLER_23_872 VPWR VGND sg13g2_decap_8
XFILLER_10_544 VPWR VGND sg13g2_decap_8
XFILLER_41_21 VPWR VGND sg13g2_decap_8
XFILLER_22_382 VPWR VGND sg13g2_decap_8
XFILLER_6_526 VPWR VGND sg13g2_decap_8
XFILLER_41_98 VPWR VGND sg13g2_decap_8
XFILLER_2_743 VPWR VGND sg13g2_decap_8
XFILLER_1_231 VPWR VGND sg13g2_decap_8
XFILLER_49_224 VPWR VGND sg13g2_decap_8
XFILLER_2_15 VPWR VGND sg13g2_decap_8
XFILLER_46_931 VPWR VGND sg13g2_decap_8
XFILLER_45_441 VPWR VGND sg13g2_decap_8
XFILLER_18_666 VPWR VGND sg13g2_decap_8
XFILLER_17_176 VPWR VGND sg13g2_decap_8
XdigitalL.g\[51\].u.inv VPWR digitalL.g\[51\].u.OUTN net102 VGND sg13g2_inv_1
XFILLER_32_102 VPWR VGND sg13g2_decap_8
XFILLER_33_658 VPWR VGND sg13g2_decap_8
XFILLER_32_179 VPWR VGND sg13g2_decap_8
XFILLER_20_319 VPWR VGND sg13g2_decap_8
XFILLER_13_393 VPWR VGND sg13g2_decap_8
XFILLER_9_386 VPWR VGND sg13g2_decap_8
XFILLER_49_791 VPWR VGND sg13g2_decap_8
XFILLER_36_441 VPWR VGND sg13g2_decap_8
XFILLER_23_102 VPWR VGND sg13g2_decap_8
XFILLER_24_669 VPWR VGND sg13g2_decap_8
XFILLER_23_179 VPWR VGND sg13g2_decap_8
XdigitalH.g\[96\].u.inv VPWR digitalH.g\[96\].u.OUTN net42 VGND sg13g2_inv_1
XFILLER_20_842 VPWR VGND sg13g2_fill_1
XdigitalH.g\[54\].u.buff net51 digitalH.g\[54\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_853 VPWR VGND sg13g2_decap_4
XFILLER_20_897 VPWR VGND sg13g2_fill_2
XFILLER_11_57 VPWR VGND sg13g2_decap_8
XFILLER_2_8 VPWR VGND sg13g2_decap_8
XFILLER_4_1009 VPWR VGND sg13g2_decap_8
XFILLER_47_728 VPWR VGND sg13g2_decap_8
XFILLER_19_408 VPWR VGND sg13g2_decap_8
XFILLER_46_238 VPWR VGND sg13g2_decap_8
XFILLER_36_21 VPWR VGND sg13g2_decap_8
XFILLER_28_942 VPWR VGND sg13g2_decap_8
XFILLER_15_603 VPWR VGND sg13g2_decap_8
XFILLER_27_441 VPWR VGND sg13g2_decap_8
XFILLER_14_113 VPWR VGND sg13g2_decap_8
XFILLER_42_455 VPWR VGND sg13g2_decap_8
XFILLER_36_98 VPWR VGND sg13g2_decap_8
XFILLER_30_606 VPWR VGND sg13g2_decap_8
XFILLER_10_341 VPWR VGND sg13g2_decap_8
XFILLER_6_323 VPWR VGND sg13g2_decap_8
XdigitalH.g\[107\].u.inv VPWR digitalH.g\[107\].u.OUTN net39 VGND sg13g2_inv_1
XFILLER_2_540 VPWR VGND sg13g2_decap_8
XFILLER_38_728 VPWR VGND sg13g2_decap_8
XFILLER_37_238 VPWR VGND sg13g2_decap_8
XdigitalenH.g\[1\].u.buff net4 digitalenH.g\[1\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_18_463 VPWR VGND sg13g2_decap_8
XFILLER_33_455 VPWR VGND sg13g2_decap_8
XFILLER_21_606 VPWR VGND sg13g2_decap_8
XFILLER_14_680 VPWR VGND sg13g2_decap_8
XFILLER_20_116 VPWR VGND sg13g2_decap_8
XFILLER_13_190 VPWR VGND sg13g2_decap_8
XFILLER_9_183 VPWR VGND sg13g2_decap_8
XFILLER_29_739 VPWR VGND sg13g2_decap_8
XFILLER_28_249 VPWR VGND sg13g2_decap_8
XFILLER_25_956 VPWR VGND sg13g2_decap_8
XFILLER_12_606 VPWR VGND sg13g2_decap_8
XFILLER_24_466 VPWR VGND sg13g2_decap_8
XFILLER_11_127 VPWR VGND sg13g2_decap_8
XdigitalH.g\[2\].u.buff net21 digitalH.g\[2\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_22_67 VPWR VGND sg13g2_decap_8
XFILLER_20_683 VPWR VGND sg13g2_decap_8
XdigitalH.g\[101\].u.buff net41 digitalH.g\[101\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_827 VPWR VGND sg13g2_decap_8
XFILLER_3_337 VPWR VGND sg13g2_decap_8
XFILLER_19_205 VPWR VGND sg13g2_decap_8
XFILLER_47_525 VPWR VGND sg13g2_decap_8
XFILLER_47_42 VPWR VGND sg13g2_decap_8
XFILLER_15_400 VPWR VGND sg13g2_decap_8
XFILLER_43_742 VPWR VGND sg13g2_decap_8
XFILLER_15_477 VPWR VGND sg13g2_decap_8
XFILLER_43_764 VPWR VGND sg13g2_fill_1
XFILLER_42_252 VPWR VGND sg13g2_decap_8
XFILLER_30_403 VPWR VGND sg13g2_decap_8
XFILLER_8_36 VPWR VGND sg13g2_decap_8
XFILLER_11_694 VPWR VGND sg13g2_decap_8
XFILLER_7_610 VPWR VGND sg13g2_decap_8
XFILLER_6_120 VPWR VGND sg13g2_decap_8
XFILLER_7_687 VPWR VGND sg13g2_decap_8
XFILLER_6_197 VPWR VGND sg13g2_decap_8
XdigitalH.g\[44\].u.inv VPWR digitalH.g\[44\].u.OUTN net47 VGND sg13g2_inv_1
XFILLER_26_4 VPWR VGND sg13g2_decap_8
XFILLER_38_525 VPWR VGND sg13g2_decap_8
X_15_ net68 net17 VPWR VGND sg13g2_buf_1
XFILLER_18_260 VPWR VGND sg13g2_decap_8
XFILLER_33_252 VPWR VGND sg13g2_decap_8
XFILLER_21_403 VPWR VGND sg13g2_decap_8
XFILLER_1_819 VPWR VGND sg13g2_decap_8
XFILLER_0_329 VPWR VGND sg13g2_decap_8
XFILLER_29_536 VPWR VGND sg13g2_decap_8
XFILLER_44_539 VPWR VGND sg13g2_decap_8
XFILLER_17_78 VPWR VGND sg13g2_decap_8
XFILLER_25_753 VPWR VGND sg13g2_decap_8
XFILLER_12_403 VPWR VGND sg13g2_decap_8
XFILLER_24_263 VPWR VGND sg13g2_decap_8
XdigitalL.g\[98\].u.inv VPWR digitalL.g\[98\].u.OUTN net88 VGND sg13g2_inv_1
XFILLER_8_407 VPWR VGND sg13g2_decap_8
XFILLER_33_77 VPWR VGND sg13g2_decap_8
XFILLER_20_480 VPWR VGND sg13g2_decap_8
XFILLER_4_624 VPWR VGND sg13g2_decap_8
XFILLER_3_134 VPWR VGND sg13g2_decap_8
XFILLER_48_812 VPWR VGND sg13g2_decap_8
XFILLER_0_896 VPWR VGND sg13g2_decap_8
XFILLER_47_322 VPWR VGND sg13g2_decap_8
XFILLER_48_889 VPWR VGND sg13g2_decap_8
XFILLER_35_539 VPWR VGND sg13g2_decap_8
XFILLER_47_399 VPWR VGND sg13g2_decap_8
XFILLER_15_274 VPWR VGND sg13g2_decap_8
XFILLER_30_200 VPWR VGND sg13g2_decap_8
XFILLER_31_789 VPWR VGND sg13g2_fill_1
XFILLER_30_277 VPWR VGND sg13g2_decap_8
XFILLER_11_491 VPWR VGND sg13g2_decap_8
XFILLER_8_952 VPWR VGND sg13g2_fill_1
XFILLER_7_484 VPWR VGND sg13g2_decap_8
XdigitalL.g\[88\].u.buff net98 digitalL.g\[88\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[17\].u.buff net74 digitalL.g\[17\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_322 VPWR VGND sg13g2_decap_8
XFILLER_17_0 VPWR VGND sg13g2_decap_4
XFILLER_0_1001 VPWR VGND sg13g2_decap_8
XFILLER_0_70 VPWR VGND sg13g2_decap_8
XFILLER_38_399 VPWR VGND sg13g2_decap_8
XFILLER_21_200 VPWR VGND sg13g2_decap_8
XFILLER_22_767 VPWR VGND sg13g2_decap_8
XFILLER_21_277 VPWR VGND sg13g2_decap_8
XFILLER_1_616 VPWR VGND sg13g2_decap_8
XFILLER_0_126 VPWR VGND sg13g2_decap_8
XFILLER_49_609 VPWR VGND sg13g2_decap_8
XFILLER_48_119 VPWR VGND sg13g2_decap_8
XFILLER_28_11 VPWR VGND sg13g2_decap_8
XFILLER_29_333 VPWR VGND sg13g2_decap_8
XFILLER_45_826 VPWR VGND sg13g2_decap_8
XFILLER_28_88 VPWR VGND sg13g2_decap_8
XFILLER_44_336 VPWR VGND sg13g2_decap_8
XFILLER_13_701 VPWR VGND sg13g2_decap_8
XFILLER_44_21 VPWR VGND sg13g2_decap_8
XFILLER_25_550 VPWR VGND sg13g2_decap_8
XFILLER_12_200 VPWR VGND sg13g2_decap_8
XFILLER_44_98 VPWR VGND sg13g2_decap_8
XFILLER_40_553 VPWR VGND sg13g2_decap_8
XFILLER_12_277 VPWR VGND sg13g2_decap_8
XFILLER_8_204 VPWR VGND sg13g2_decap_8
XFILLER_9_738 VPWR VGND sg13g2_fill_1
XFILLER_5_911 VPWR VGND sg13g2_decap_8
XFILLER_4_421 VPWR VGND sg13g2_decap_8
XFILLER_5_15 VPWR VGND sg13g2_decap_8
XFILLER_5_988 VPWR VGND sg13g2_decap_8
XFILLER_4_498 VPWR VGND sg13g2_decap_8
XFILLER_39_119 VPWR VGND sg13g2_decap_8
XFILLER_0_693 VPWR VGND sg13g2_decap_8
XFILLER_48_686 VPWR VGND sg13g2_decap_8
XFILLER_47_196 VPWR VGND sg13g2_decap_8
XFILLER_35_336 VPWR VGND sg13g2_decap_8
XFILLER_16_561 VPWR VGND sg13g2_decap_8
XFILLER_44_892 VPWR VGND sg13g2_decap_8
XFILLER_31_564 VPWR VGND sg13g2_decap_8
XFILLER_7_281 VPWR VGND sg13g2_decap_8
XdigitalL.g\[46\].u.inv VPWR digitalL.g\[46\].u.OUTN net95 VGND sg13g2_inv_1
XdigitalH.g\[79\].u.buff net58 digitalH.g\[79\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_686 VPWR VGND sg13g2_decap_8
XFILLER_27_826 VPWR VGND sg13g2_decap_8
XFILLER_38_196 VPWR VGND sg13g2_decap_8
XFILLER_26_347 VPWR VGND sg13g2_decap_8
XFILLER_10_726 VPWR VGND sg13g2_decap_4
XFILLER_14_57 VPWR VGND sg13g2_decap_8
XFILLER_22_564 VPWR VGND sg13g2_decap_8
XFILLER_6_708 VPWR VGND sg13g2_decap_8
XFILLER_5_218 VPWR VGND sg13g2_decap_8
XFILLER_30_67 VPWR VGND sg13g2_decap_8
XFILLER_2_925 VPWR VGND sg13g2_decap_8
XFILLER_1_413 VPWR VGND sg13g2_decap_8
XFILLER_49_406 VPWR VGND sg13g2_decap_8
XFILLER_39_21 VPWR VGND sg13g2_decap_8
XFILLER_39_98 VPWR VGND sg13g2_decap_8
XFILLER_29_130 VPWR VGND sg13g2_decap_8
XFILLER_45_623 VPWR VGND sg13g2_decap_8
XFILLER_17_358 VPWR VGND sg13g2_decap_8
XFILLER_44_133 VPWR VGND sg13g2_decap_8
XFILLER_13_575 VPWR VGND sg13g2_decap_8
XFILLER_40_350 VPWR VGND sg13g2_decap_8
XFILLER_9_568 VPWR VGND sg13g2_decap_8
XFILLER_5_785 VPWR VGND sg13g2_decap_8
XFILLER_4_295 VPWR VGND sg13g2_decap_8
XFILLER_1_980 VPWR VGND sg13g2_decap_8
XFILLER_0_490 VPWR VGND sg13g2_decap_8
XFILLER_49_973 VPWR VGND sg13g2_decap_8
XFILLER_48_483 VPWR VGND sg13g2_decap_8
XFILLER_36_623 VPWR VGND sg13g2_decap_8
XFILLER_35_133 VPWR VGND sg13g2_decap_8
XFILLER_32_862 VPWR VGND sg13g2_fill_1
XFILLER_31_361 VPWR VGND sg13g2_decap_8
XdigitalL.g\[32\].u.buff net84 digitalL.g\[32\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[92\].u.inv VPWR digitalH.g\[92\].u.OUTN net55 VGND sg13g2_inv_1
XdigitalH.g\[126\].u.buff net22 digitalH.g\[126\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_39_483 VPWR VGND sg13g2_decap_8
XFILLER_27_623 VPWR VGND sg13g2_decap_8
XFILLER_26_144 VPWR VGND sg13g2_decap_8
XFILLER_42_637 VPWR VGND sg13g2_decap_8
XFILLER_41_147 VPWR VGND sg13g2_decap_8
XFILLER_25_67 VPWR VGND sg13g2_decap_8
XFILLER_23_851 VPWR VGND sg13g2_decap_8
XFILLER_22_361 VPWR VGND sg13g2_decap_8
XFILLER_10_523 VPWR VGND sg13g2_decap_8
XFILLER_6_505 VPWR VGND sg13g2_decap_8
XFILLER_41_77 VPWR VGND sg13g2_decap_8
XFILLER_2_722 VPWR VGND sg13g2_decap_8
XFILLER_29_1019 VPWR VGND sg13g2_decap_8
XFILLER_1_210 VPWR VGND sg13g2_decap_8
XFILLER_49_203 VPWR VGND sg13g2_decap_8
XFILLER_2_799 VPWR VGND sg13g2_decap_8
XFILLER_1_287 VPWR VGND sg13g2_decap_8
XFILLER_46_910 VPWR VGND sg13g2_decap_8
XFILLER_45_420 VPWR VGND sg13g2_decap_8
XFILLER_18_645 VPWR VGND sg13g2_decap_8
XFILLER_17_155 VPWR VGND sg13g2_decap_8
XFILLER_46_987 VPWR VGND sg13g2_decap_8
XdigitalH.g\[103\].u.inv VPWR digitalH.g\[103\].u.OUTN net40 VGND sg13g2_inv_1
XFILLER_45_497 VPWR VGND sg13g2_decap_8
XFILLER_33_637 VPWR VGND sg13g2_decap_8
XFILLER_32_158 VPWR VGND sg13g2_decap_8
XFILLER_13_372 VPWR VGND sg13g2_decap_8
XFILLER_9_365 VPWR VGND sg13g2_decap_8
XFILLER_5_582 VPWR VGND sg13g2_decap_8
XFILLER_49_770 VPWR VGND sg13g2_decap_8
XFILLER_48_280 VPWR VGND sg13g2_decap_8
XFILLER_36_420 VPWR VGND sg13g2_decap_8
XFILLER_36_497 VPWR VGND sg13g2_decap_8
XFILLER_24_648 VPWR VGND sg13g2_decap_8
XFILLER_11_309 VPWR VGND sg13g2_decap_8
XFILLER_23_158 VPWR VGND sg13g2_decap_8
XdigitalH.g\[39\].u.inv VPWR digitalH.g\[39\].u.OUTN net45 VGND sg13g2_inv_1
XFILLER_20_821 VPWR VGND sg13g2_fill_1
XdigitalL.g\[116\].u.buff net78 digitalL.g\[116\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_887 VPWR VGND sg13g2_fill_2
XFILLER_11_36 VPWR VGND sg13g2_decap_8
XdigitalH.g\[94\].u.buff net42 digitalH.g\[94\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_3_519 VPWR VGND sg13g2_decap_8
XdigitalH.g\[23\].u.buff net28 digitalH.g\[23\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_707 VPWR VGND sg13g2_decap_8
XFILLER_46_217 VPWR VGND sg13g2_decap_8
XFILLER_39_280 VPWR VGND sg13g2_decap_8
XFILLER_28_921 VPWR VGND sg13g2_decap_8
XFILLER_27_420 VPWR VGND sg13g2_decap_8
XFILLER_36_77 VPWR VGND sg13g2_decap_8
XFILLER_28_998 VPWR VGND sg13g2_decap_8
XFILLER_15_659 VPWR VGND sg13g2_decap_8
XFILLER_42_434 VPWR VGND sg13g2_decap_8
XFILLER_27_497 VPWR VGND sg13g2_decap_8
XFILLER_14_169 VPWR VGND sg13g2_decap_8
XFILLER_10_320 VPWR VGND sg13g2_decap_8
XFILLER_6_302 VPWR VGND sg13g2_decap_8
XFILLER_10_397 VPWR VGND sg13g2_decap_8
XFILLER_6_379 VPWR VGND sg13g2_decap_8
XFILLER_2_596 VPWR VGND sg13g2_decap_8
XFILLER_38_707 VPWR VGND sg13g2_decap_8
XFILLER_37_217 VPWR VGND sg13g2_decap_8
XFILLER_19_932 VPWR VGND sg13g2_fill_1
XFILLER_18_442 VPWR VGND sg13g2_decap_8
XFILLER_46_784 VPWR VGND sg13g2_decap_8
XFILLER_45_294 VPWR VGND sg13g2_decap_8
XFILLER_33_434 VPWR VGND sg13g2_decap_8
XdigitalH.g\[40\].u.inv VPWR digitalH.g\[40\].u.OUTN net66 VGND sg13g2_inv_1
XdigitalL.g\[7\].u.buff net71 digitalL.g\[7\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_9_162 VPWR VGND sg13g2_decap_8
XFILLER_6_880 VPWR VGND sg13g2_fill_2
XFILLER_47_0 VPWR VGND sg13g2_decap_8
XFILLER_3_92 VPWR VGND sg13g2_decap_8
XFILLER_29_718 VPWR VGND sg13g2_decap_8
XFILLER_28_228 VPWR VGND sg13g2_decap_8
XFILLER_25_935 VPWR VGND sg13g2_decap_8
XFILLER_36_294 VPWR VGND sg13g2_decap_8
XFILLER_24_445 VPWR VGND sg13g2_decap_8
XFILLER_11_106 VPWR VGND sg13g2_decap_8
XFILLER_22_46 VPWR VGND sg13g2_decap_8
XFILLER_20_662 VPWR VGND sg13g2_decap_8
XFILLER_4_806 VPWR VGND sg13g2_decap_8
XFILLER_3_316 VPWR VGND sg13g2_decap_8
XdigitalL.g\[94\].u.inv VPWR digitalL.g\[94\].u.OUTN net89 VGND sg13g2_inv_1
XFILLER_47_504 VPWR VGND sg13g2_decap_8
XFILLER_47_21 VPWR VGND sg13g2_decap_8
XFILLER_47_98 VPWR VGND sg13g2_decap_8
XFILLER_28_795 VPWR VGND sg13g2_decap_8
XFILLER_43_721 VPWR VGND sg13g2_decap_8
XFILLER_27_294 VPWR VGND sg13g2_decap_8
XFILLER_15_456 VPWR VGND sg13g2_decap_8
XFILLER_42_231 VPWR VGND sg13g2_decap_8
XFILLER_8_15 VPWR VGND sg13g2_decap_8
XFILLER_30_459 VPWR VGND sg13g2_decap_8
XFILLER_11_673 VPWR VGND sg13g2_decap_8
XFILLER_10_194 VPWR VGND sg13g2_decap_8
XFILLER_7_666 VPWR VGND sg13g2_decap_8
XFILLER_6_176 VPWR VGND sg13g2_decap_8
XFILLER_40_7 VPWR VGND sg13g2_decap_8
XFILLER_3_883 VPWR VGND sg13g2_decap_8
XFILLER_2_393 VPWR VGND sg13g2_decap_8
XFILLER_38_504 VPWR VGND sg13g2_decap_8
XFILLER_19_4 VPWR VGND sg13g2_fill_1
X_14_ net68 net16 VPWR VGND sg13g2_buf_1
XFILLER_19_751 VPWR VGND sg13g2_decap_8
XFILLER_46_581 VPWR VGND sg13g2_decap_8
XFILLER_19_795 VPWR VGND sg13g2_fill_1
XFILLER_33_231 VPWR VGND sg13g2_decap_8
XFILLER_22_949 VPWR VGND sg13g2_decap_8
XFILLER_21_459 VPWR VGND sg13g2_decap_8
XFILLER_30_982 VPWR VGND sg13g2_decap_4
XFILLER_0_308 VPWR VGND sg13g2_decap_8
XFILLER_29_515 VPWR VGND sg13g2_decap_8
XFILLER_44_518 VPWR VGND sg13g2_decap_8
XFILLER_17_57 VPWR VGND sg13g2_decap_8
XFILLER_37_581 VPWR VGND sg13g2_decap_8
XFILLER_25_732 VPWR VGND sg13g2_decap_8
XFILLER_24_242 VPWR VGND sg13g2_decap_8
XFILLER_12_459 VPWR VGND sg13g2_decap_8
XFILLER_33_56 VPWR VGND sg13g2_decap_8
XFILLER_32_1004 VPWR VGND sg13g2_fill_1
XFILLER_32_1026 VPWR VGND sg13g2_fill_2
XFILLER_4_603 VPWR VGND sg13g2_decap_8
XFILLER_3_113 VPWR VGND sg13g2_decap_8
XFILLER_0_875 VPWR VGND sg13g2_decap_8
XFILLER_47_301 VPWR VGND sg13g2_decap_8
XFILLER_48_868 VPWR VGND sg13g2_decap_8
XFILLER_47_378 VPWR VGND sg13g2_decap_8
XFILLER_35_518 VPWR VGND sg13g2_decap_8
XFILLER_28_592 VPWR VGND sg13g2_decap_8
XFILLER_15_253 VPWR VGND sg13g2_decap_8
XFILLER_43_595 VPWR VGND sg13g2_decap_8
XFILLER_31_746 VPWR VGND sg13g2_decap_8
XFILLER_30_256 VPWR VGND sg13g2_decap_8
XFILLER_11_470 VPWR VGND sg13g2_decap_8
XFILLER_7_463 VPWR VGND sg13g2_decap_8
XFILLER_48_1022 VPWR VGND sg13g2_decap_8
XFILLER_3_680 VPWR VGND sg13g2_decap_8
XFILLER_2_190 VPWR VGND sg13g2_decap_8
XFILLER_38_301 VPWR VGND sg13g2_decap_8
XdigitalL.g\[57\].u.buff net104 digitalL.g\[57\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_378 VPWR VGND sg13g2_decap_8
XFILLER_26_529 VPWR VGND sg13g2_decap_8
XdigitalL.g\[42\].u.inv VPWR digitalL.g\[42\].u.OUTN net94 VGND sg13g2_inv_1
XFILLER_34_595 VPWR VGND sg13g2_decap_8
XFILLER_22_746 VPWR VGND sg13g2_decap_8
XFILLER_21_256 VPWR VGND sg13g2_decap_8
XFILLER_0_105 VPWR VGND sg13g2_decap_8
XFILLER_29_312 VPWR VGND sg13g2_decap_8
XFILLER_45_805 VPWR VGND sg13g2_decap_8
XFILLER_28_67 VPWR VGND sg13g2_decap_8
XFILLER_44_315 VPWR VGND sg13g2_decap_8
XFILLER_29_389 VPWR VGND sg13g2_decap_8
XFILLER_44_77 VPWR VGND sg13g2_decap_8
XFILLER_40_532 VPWR VGND sg13g2_decap_8
XFILLER_12_256 VPWR VGND sg13g2_decap_8
XdigitalH.g\[87\].u.inv VPWR digitalH.g\[87\].u.OUTN net55 VGND sg13g2_inv_1
XFILLER_4_400 VPWR VGND sg13g2_decap_8
XFILLER_5_967 VPWR VGND sg13g2_decap_8
XFILLER_4_477 VPWR VGND sg13g2_decap_8
XFILLER_0_672 VPWR VGND sg13g2_decap_8
XFILLER_48_665 VPWR VGND sg13g2_decap_8
XFILLER_47_175 VPWR VGND sg13g2_decap_8
XFILLER_35_315 VPWR VGND sg13g2_decap_8
XFILLER_16_540 VPWR VGND sg13g2_decap_8
XFILLER_44_871 VPWR VGND sg13g2_decap_8
XFILLER_43_392 VPWR VGND sg13g2_decap_8
XFILLER_31_543 VPWR VGND sg13g2_decap_8
XFILLER_7_260 VPWR VGND sg13g2_decap_8
XFILLER_39_665 VPWR VGND sg13g2_decap_8
XFILLER_27_805 VPWR VGND sg13g2_decap_8
XdigitalH.g\[48\].u.buff net49 digitalH.g\[48\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_38_175 VPWR VGND sg13g2_decap_8
XFILLER_26_326 VPWR VGND sg13g2_decap_8
XFILLER_41_329 VPWR VGND sg13g2_decap_8
XFILLER_14_36 VPWR VGND sg13g2_decap_8
XFILLER_34_392 VPWR VGND sg13g2_decap_8
XFILLER_22_543 VPWR VGND sg13g2_decap_8
XFILLER_10_705 VPWR VGND sg13g2_decap_8
XFILLER_30_46 VPWR VGND sg13g2_decap_8
XFILLER_2_904 VPWR VGND sg13g2_decap_8
XFILLER_7_1008 VPWR VGND sg13g2_fill_1
XFILLER_1_469 VPWR VGND sg13g2_decap_8
XFILLER_39_77 VPWR VGND sg13g2_decap_8
XFILLER_45_602 VPWR VGND sg13g2_decap_8
XFILLER_18_827 VPWR VGND sg13g2_fill_2
XFILLER_17_337 VPWR VGND sg13g2_decap_8
XFILLER_44_112 VPWR VGND sg13g2_decap_8
XFILLER_29_186 VPWR VGND sg13g2_decap_8
XFILLER_45_679 VPWR VGND sg13g2_decap_8
XFILLER_44_189 VPWR VGND sg13g2_decap_8
XFILLER_26_893 VPWR VGND sg13g2_decap_8
XFILLER_13_554 VPWR VGND sg13g2_decap_8
XFILLER_9_547 VPWR VGND sg13g2_decap_8
XFILLER_5_764 VPWR VGND sg13g2_decap_8
XFILLER_4_274 VPWR VGND sg13g2_decap_8
XFILLER_49_952 VPWR VGND sg13g2_decap_8
XFILLER_48_462 VPWR VGND sg13g2_decap_8
XFILLER_36_602 VPWR VGND sg13g2_decap_8
XFILLER_35_112 VPWR VGND sg13g2_decap_8
XFILLER_36_679 VPWR VGND sg13g2_decap_8
XFILLER_35_189 VPWR VGND sg13g2_decap_8
XFILLER_31_340 VPWR VGND sg13g2_decap_8
XFILLER_6_92 VPWR VGND sg13g2_decap_8
XdigitalL.g\[72\].u.buff net108 digitalL.g\[72\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[35\].u.inv VPWR digitalH.g\[35\].u.OUTN net44 VGND sg13g2_inv_1
XFILLER_39_462 VPWR VGND sg13g2_decap_8
XFILLER_27_602 VPWR VGND sg13g2_decap_8
XFILLER_27_679 VPWR VGND sg13g2_decap_8
XFILLER_26_123 VPWR VGND sg13g2_decap_8
XFILLER_42_616 VPWR VGND sg13g2_decap_8
XFILLER_41_126 VPWR VGND sg13g2_decap_8
XFILLER_25_46 VPWR VGND sg13g2_decap_8
XFILLER_23_830 VPWR VGND sg13g2_decap_8
XFILLER_10_502 VPWR VGND sg13g2_decap_8
XFILLER_22_340 VPWR VGND sg13g2_decap_8
XFILLER_41_56 VPWR VGND sg13g2_decap_8
XFILLER_10_579 VPWR VGND sg13g2_decap_8
XFILLER_2_701 VPWR VGND sg13g2_decap_8
XFILLER_2_778 VPWR VGND sg13g2_decap_8
XFILLER_1_266 VPWR VGND sg13g2_decap_8
XFILLER_49_259 VPWR VGND sg13g2_decap_8
XFILLER_18_624 VPWR VGND sg13g2_decap_8
XFILLER_17_134 VPWR VGND sg13g2_decap_8
XFILLER_46_966 VPWR VGND sg13g2_decap_8
XFILLER_45_476 VPWR VGND sg13g2_decap_8
XFILLER_33_616 VPWR VGND sg13g2_decap_8
XFILLER_32_137 VPWR VGND sg13g2_decap_8
XFILLER_26_690 VPWR VGND sg13g2_decap_8
XFILLER_13_351 VPWR VGND sg13g2_decap_8
XdigitalL.g\[89\].u.inv VPWR digitalL.g\[89\].u.OUTN net98 VGND sg13g2_inv_1
XFILLER_41_693 VPWR VGND sg13g2_decap_8
XFILLER_9_344 VPWR VGND sg13g2_decap_8
XFILLER_5_561 VPWR VGND sg13g2_decap_8
XFILLER_36_476 VPWR VGND sg13g2_decap_8
XFILLER_24_627 VPWR VGND sg13g2_decap_8
XFILLER_23_137 VPWR VGND sg13g2_decap_8
XFILLER_11_15 VPWR VGND sg13g2_decap_8
XFILLER_20_899 VPWR VGND sg13g2_fill_1
XdigitalH.g\[63\].u.buff net53 digitalH.g\[63\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_28_900 VPWR VGND sg13g2_decap_8
XFILLER_28_977 VPWR VGND sg13g2_decap_8
XFILLER_42_413 VPWR VGND sg13g2_decap_8
XFILLER_36_56 VPWR VGND sg13g2_decap_8
XFILLER_27_476 VPWR VGND sg13g2_decap_8
XFILLER_15_638 VPWR VGND sg13g2_decap_8
XFILLER_14_148 VPWR VGND sg13g2_decap_8
XdigitalL.g\[90\].u.inv VPWR digitalL.g\[90\].u.OUTN net98 VGND sg13g2_inv_1
XFILLER_7_815 VPWR VGND sg13g2_fill_1
XFILLER_10_376 VPWR VGND sg13g2_decap_8
XFILLER_7_848 VPWR VGND sg13g2_fill_1
XFILLER_6_358 VPWR VGND sg13g2_decap_8
XFILLER_7_0 VPWR VGND sg13g2_decap_4
XFILLER_2_575 VPWR VGND sg13g2_decap_8
XFILLER_42_1017 VPWR VGND sg13g2_fill_2
XFILLER_19_900 VPWR VGND sg13g2_decap_4
XFILLER_18_421 VPWR VGND sg13g2_decap_8
XFILLER_46_763 VPWR VGND sg13g2_decap_8
XFILLER_45_273 VPWR VGND sg13g2_decap_8
XFILLER_33_413 VPWR VGND sg13g2_decap_8
XFILLER_18_498 VPWR VGND sg13g2_decap_8
XFILLER_9_141 VPWR VGND sg13g2_decap_8
XFILLER_41_490 VPWR VGND sg13g2_decap_8
XFILLER_3_71 VPWR VGND sg13g2_decap_8
XFILLER_28_207 VPWR VGND sg13g2_decap_8
XFILLER_25_914 VPWR VGND sg13g2_decap_8
XFILLER_36_273 VPWR VGND sg13g2_decap_8
XFILLER_24_424 VPWR VGND sg13g2_decap_8
XFILLER_22_25 VPWR VGND sg13g2_decap_8
XFILLER_20_641 VPWR VGND sg13g2_decap_8
XFILLER_0_7 VPWR VGND sg13g2_decap_8
XdigitalL.g\[37\].u.inv VPWR digitalL.g\[37\].u.OUTN net93 VGND sg13g2_inv_1
XdigitalH.g\[110\].u.buff net37 digitalH.g\[110\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_77 VPWR VGND sg13g2_decap_8
XFILLER_43_700 VPWR VGND sg13g2_decap_8
XFILLER_28_774 VPWR VGND sg13g2_decap_8
XFILLER_15_435 VPWR VGND sg13g2_decap_8
XFILLER_42_210 VPWR VGND sg13g2_decap_8
XFILLER_27_273 VPWR VGND sg13g2_decap_8
XFILLER_42_287 VPWR VGND sg13g2_decap_8
XFILLER_31_939 VPWR VGND sg13g2_fill_1
XFILLER_30_438 VPWR VGND sg13g2_decap_8
XFILLER_24_991 VPWR VGND sg13g2_decap_8
XFILLER_11_652 VPWR VGND sg13g2_decap_8
XFILLER_10_173 VPWR VGND sg13g2_decap_8
XFILLER_7_645 VPWR VGND sg13g2_decap_8
XFILLER_6_155 VPWR VGND sg13g2_decap_8
XFILLER_3_862 VPWR VGND sg13g2_decap_8
XFILLER_33_7 VPWR VGND sg13g2_decap_8
XFILLER_2_372 VPWR VGND sg13g2_decap_8
X_13_ net68 net15 VPWR VGND sg13g2_buf_1
XFILLER_19_730 VPWR VGND sg13g2_decap_8
XFILLER_46_560 VPWR VGND sg13g2_decap_8
XFILLER_34_700 VPWR VGND sg13g2_decap_8
XFILLER_33_210 VPWR VGND sg13g2_decap_8
XFILLER_18_295 VPWR VGND sg13g2_decap_8
XFILLER_33_287 VPWR VGND sg13g2_decap_8
XFILLER_22_928 VPWR VGND sg13g2_decap_8
XFILLER_21_438 VPWR VGND sg13g2_decap_8
XFILLER_30_961 VPWR VGND sg13g2_decap_8
XFILLER_25_1012 VPWR VGND sg13g2_decap_8
XFILLER_17_36 VPWR VGND sg13g2_decap_8
XFILLER_37_560 VPWR VGND sg13g2_decap_8
XFILLER_25_711 VPWR VGND sg13g2_decap_8
XFILLER_24_221 VPWR VGND sg13g2_decap_8
XFILLER_40_714 VPWR VGND sg13g2_decap_8
XFILLER_25_788 VPWR VGND sg13g2_decap_8
XFILLER_12_438 VPWR VGND sg13g2_decap_8
XFILLER_33_35 VPWR VGND sg13g2_decap_8
XFILLER_24_298 VPWR VGND sg13g2_decap_8
XdigitalL.g\[100\].u.buff net88 digitalL.g\[100\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_21_983 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[2\].u.inv VPWR digitalenL.g\[2\].u.OUTN net3 VGND sg13g2_inv_1
XFILLER_4_659 VPWR VGND sg13g2_decap_8
XFILLER_3_169 VPWR VGND sg13g2_decap_8
XFILLER_0_854 VPWR VGND sg13g2_decap_8
XdigitalH.g\[83\].u.inv VPWR digitalH.g\[83\].u.OUTN net57 VGND sg13g2_inv_1
XFILLER_48_847 VPWR VGND sg13g2_decap_8
XFILLER_47_357 VPWR VGND sg13g2_decap_8
XFILLER_28_571 VPWR VGND sg13g2_decap_8
XFILLER_15_232 VPWR VGND sg13g2_decap_8
XFILLER_43_574 VPWR VGND sg13g2_decap_8
XFILLER_31_725 VPWR VGND sg13g2_decap_8
XFILLER_30_235 VPWR VGND sg13g2_decap_8
XFILLER_7_442 VPWR VGND sg13g2_decap_8
XFILLER_8_976 VPWR VGND sg13g2_fill_1
XFILLER_48_1001 VPWR VGND sg13g2_decap_8
XFILLER_31_4 VPWR VGND sg13g2_decap_8
XFILLER_38_357 VPWR VGND sg13g2_decap_8
XFILLER_26_508 VPWR VGND sg13g2_decap_8
XdigitalL.g\[97\].u.buff net89 digitalL.g\[97\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[26\].u.buff net83 digitalL.g\[26\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_34_574 VPWR VGND sg13g2_decap_8
XFILLER_22_725 VPWR VGND sg13g2_decap_8
XFILLER_21_235 VPWR VGND sg13g2_decap_8
XFILLER_9_92 VPWR VGND sg13g2_decap_8
XFILLER_28_46 VPWR VGND sg13g2_decap_8
XFILLER_17_519 VPWR VGND sg13g2_decap_8
XFILLER_29_368 VPWR VGND sg13g2_decap_8
XFILLER_44_56 VPWR VGND sg13g2_decap_8
XFILLER_40_511 VPWR VGND sg13g2_decap_8
XFILLER_25_585 VPWR VGND sg13g2_decap_8
XFILLER_12_235 VPWR VGND sg13g2_decap_8
XFILLER_13_736 VPWR VGND sg13g2_fill_2
XFILLER_9_729 VPWR VGND sg13g2_fill_2
XFILLER_40_588 VPWR VGND sg13g2_decap_8
XFILLER_8_239 VPWR VGND sg13g2_decap_8
XFILLER_5_946 VPWR VGND sg13g2_decap_8
XFILLER_4_456 VPWR VGND sg13g2_decap_8
XFILLER_0_651 VPWR VGND sg13g2_decap_8
XFILLER_48_644 VPWR VGND sg13g2_decap_8
XFILLER_47_154 VPWR VGND sg13g2_decap_8
XFILLER_44_850 VPWR VGND sg13g2_decap_8
XFILLER_43_371 VPWR VGND sg13g2_decap_8
XFILLER_16_596 VPWR VGND sg13g2_decap_8
XFILLER_31_522 VPWR VGND sg13g2_decap_8
XFILLER_8_740 VPWR VGND sg13g2_fill_2
XFILLER_31_599 VPWR VGND sg13g2_decap_8
XFILLER_39_644 VPWR VGND sg13g2_decap_8
XFILLER_38_154 VPWR VGND sg13g2_decap_8
XFILLER_22_1026 VPWR VGND sg13g2_fill_2
XFILLER_26_305 VPWR VGND sg13g2_decap_8
XFILLER_41_308 VPWR VGND sg13g2_decap_8
XFILLER_14_15 VPWR VGND sg13g2_decap_8
XdigitalH.g\[88\].u.buff net56 digitalH.g\[88\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_34_371 VPWR VGND sg13g2_decap_8
XFILLER_22_522 VPWR VGND sg13g2_decap_8
XdigitalH.g\[17\].u.buff net27 digitalH.g\[17\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[31\].u.inv VPWR digitalH.g\[31\].u.OUTN net31 VGND sg13g2_inv_1
XFILLER_22_599 VPWR VGND sg13g2_decap_8
XFILLER_30_25 VPWR VGND sg13g2_decap_8
XFILLER_1_448 VPWR VGND sg13g2_decap_8
XFILLER_39_56 VPWR VGND sg13g2_decap_8
XFILLER_18_806 VPWR VGND sg13g2_fill_2
XFILLER_17_316 VPWR VGND sg13g2_decap_8
XFILLER_29_165 VPWR VGND sg13g2_decap_8
XFILLER_45_658 VPWR VGND sg13g2_decap_8
XFILLER_44_168 VPWR VGND sg13g2_decap_8
XFILLER_32_319 VPWR VGND sg13g2_decap_8
XFILLER_26_872 VPWR VGND sg13g2_decap_8
XFILLER_13_533 VPWR VGND sg13g2_decap_8
XFILLER_25_382 VPWR VGND sg13g2_decap_8
XFILLER_9_526 VPWR VGND sg13g2_decap_8
XFILLER_40_385 VPWR VGND sg13g2_decap_8
XFILLER_5_743 VPWR VGND sg13g2_decap_8
XFILLER_4_253 VPWR VGND sg13g2_decap_8
XdigitalL.g\[85\].u.inv VPWR digitalL.g\[85\].u.OUTN net99 VGND sg13g2_inv_1
XFILLER_45_1015 VPWR VGND sg13g2_decap_8
XFILLER_49_931 VPWR VGND sg13g2_decap_8
XFILLER_48_441 VPWR VGND sg13g2_decap_8
XFILLER_36_658 VPWR VGND sg13g2_decap_8
XFILLER_24_809 VPWR VGND sg13g2_decap_8
XFILLER_35_168 VPWR VGND sg13g2_decap_8
XFILLER_23_319 VPWR VGND sg13g2_decap_8
XFILLER_16_393 VPWR VGND sg13g2_decap_8
XFILLER_32_820 VPWR VGND sg13g2_fill_1
XFILLER_32_875 VPWR VGND sg13g2_fill_1
XFILLER_32_853 VPWR VGND sg13g2_fill_2
XFILLER_31_396 VPWR VGND sg13g2_decap_8
XFILLER_6_71 VPWR VGND sg13g2_decap_8
XFILLER_39_441 VPWR VGND sg13g2_decap_8
XdigitalL.g\[41\].u.buff net94 digitalL.g\[41\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_26_102 VPWR VGND sg13g2_decap_8
XFILLER_27_658 VPWR VGND sg13g2_decap_8
XFILLER_41_105 VPWR VGND sg13g2_decap_8
XFILLER_26_179 VPWR VGND sg13g2_decap_8
XFILLER_25_25 VPWR VGND sg13g2_decap_8
XFILLER_23_886 VPWR VGND sg13g2_decap_8
XFILLER_10_558 VPWR VGND sg13g2_decap_8
XFILLER_41_35 VPWR VGND sg13g2_decap_8
XFILLER_22_396 VPWR VGND sg13g2_decap_8
XFILLER_2_757 VPWR VGND sg13g2_decap_8
XFILLER_1_245 VPWR VGND sg13g2_decap_8
XFILLER_49_238 VPWR VGND sg13g2_decap_8
XFILLER_2_29 VPWR VGND sg13g2_decap_8
XFILLER_46_945 VPWR VGND sg13g2_decap_8
XFILLER_18_603 VPWR VGND sg13g2_decap_8
XFILLER_17_113 VPWR VGND sg13g2_decap_8
XFILLER_45_455 VPWR VGND sg13g2_decap_8
XFILLER_32_116 VPWR VGND sg13g2_decap_8
XFILLER_13_330 VPWR VGND sg13g2_decap_8
XFILLER_9_323 VPWR VGND sg13g2_decap_8
XFILLER_41_672 VPWR VGND sg13g2_decap_8
XFILLER_40_182 VPWR VGND sg13g2_decap_8
XFILLER_5_540 VPWR VGND sg13g2_decap_8
XFILLER_36_455 VPWR VGND sg13g2_decap_8
XFILLER_24_606 VPWR VGND sg13g2_decap_8
XFILLER_17_680 VPWR VGND sg13g2_decap_8
XFILLER_23_116 VPWR VGND sg13g2_decap_8
XFILLER_16_190 VPWR VGND sg13g2_decap_8
XFILLER_32_683 VPWR VGND sg13g2_decap_8
XFILLER_20_834 VPWR VGND sg13g2_fill_2
XFILLER_20_812 VPWR VGND sg13g2_fill_1
XFILLER_31_193 VPWR VGND sg13g2_decap_8
XdigitalL.g\[125\].u.buff net69 digitalL.g\[125\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_36_35 VPWR VGND sg13g2_decap_8
XFILLER_28_956 VPWR VGND sg13g2_decap_8
XFILLER_15_617 VPWR VGND sg13g2_decap_8
XdigitalH.g\[32\].u.buff net31 digitalH.g\[32\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_43_904 VPWR VGND sg13g2_fill_1
XFILLER_27_455 VPWR VGND sg13g2_decap_8
XFILLER_14_127 VPWR VGND sg13g2_decap_8
XdigitalL.g\[33\].u.inv VPWR digitalL.g\[33\].u.OUTN net92 VGND sg13g2_inv_1
XFILLER_42_469 VPWR VGND sg13g2_decap_8
XFILLER_23_683 VPWR VGND sg13g2_decap_8
XFILLER_22_193 VPWR VGND sg13g2_decap_8
XFILLER_10_355 VPWR VGND sg13g2_decap_8
XFILLER_6_337 VPWR VGND sg13g2_decap_8
XFILLER_2_554 VPWR VGND sg13g2_decap_8
XFILLER_18_400 VPWR VGND sg13g2_decap_8
XFILLER_46_742 VPWR VGND sg13g2_decap_8
XFILLER_45_252 VPWR VGND sg13g2_decap_8
XFILLER_18_477 VPWR VGND sg13g2_decap_8
XFILLER_33_469 VPWR VGND sg13g2_decap_8
XFILLER_14_694 VPWR VGND sg13g2_decap_8
XFILLER_9_120 VPWR VGND sg13g2_decap_8
XdigitalH.g\[78\].u.inv VPWR digitalH.g\[78\].u.OUTN net60 VGND sg13g2_inv_1
XFILLER_9_197 VPWR VGND sg13g2_decap_8
XFILLER_3_50 VPWR VGND sg13g2_decap_8
XFILLER_3_1023 VPWR VGND sg13g2_decap_4
XFILLER_36_252 VPWR VGND sg13g2_decap_8
XFILLER_24_403 VPWR VGND sg13g2_decap_8
XFILLER_32_480 VPWR VGND sg13g2_decap_8
XFILLER_20_620 VPWR VGND sg13g2_decap_8
XFILLER_20_697 VPWR VGND sg13g2_decap_8
Xfanout110 net111 net110 VPWR VGND sg13g2_buf_1
XFILLER_19_219 VPWR VGND sg13g2_decap_8
XFILLER_47_56 VPWR VGND sg13g2_decap_8
XFILLER_47_539 VPWR VGND sg13g2_decap_8
XFILLER_28_753 VPWR VGND sg13g2_decap_8
XFILLER_27_252 VPWR VGND sg13g2_decap_8
XFILLER_15_414 VPWR VGND sg13g2_decap_8
XFILLER_43_778 VPWR VGND sg13g2_fill_1
XFILLER_43_756 VPWR VGND sg13g2_decap_4
XFILLER_42_266 VPWR VGND sg13g2_decap_8
XFILLER_30_417 VPWR VGND sg13g2_decap_8
XFILLER_24_970 VPWR VGND sg13g2_decap_8
XFILLER_11_631 VPWR VGND sg13g2_decap_8
XFILLER_23_480 VPWR VGND sg13g2_decap_8
XFILLER_10_152 VPWR VGND sg13g2_decap_8
XFILLER_7_624 VPWR VGND sg13g2_decap_8
XFILLER_6_134 VPWR VGND sg13g2_decap_8
XFILLER_12_81 VPWR VGND sg13g2_decap_8
XFILLER_3_841 VPWR VGND sg13g2_decap_8
XFILLER_2_351 VPWR VGND sg13g2_decap_8
X_12_ net68 net14 VPWR VGND sg13g2_buf_1
XFILLER_38_539 VPWR VGND sg13g2_decap_8
XFILLER_18_274 VPWR VGND sg13g2_decap_8
XFILLER_22_907 VPWR VGND sg13g2_decap_8
XFILLER_33_266 VPWR VGND sg13g2_decap_8
XFILLER_21_417 VPWR VGND sg13g2_decap_8
XFILLER_14_491 VPWR VGND sg13g2_decap_8
XFILLER_30_940 VPWR VGND sg13g2_decap_8
XFILLER_17_15 VPWR VGND sg13g2_decap_8
XFILLER_24_200 VPWR VGND sg13g2_decap_8
XFILLER_25_767 VPWR VGND sg13g2_decap_8
XFILLER_12_417 VPWR VGND sg13g2_decap_8
XFILLER_33_14 VPWR VGND sg13g2_decap_8
XFILLER_24_277 VPWR VGND sg13g2_decap_8
XFILLER_32_1028 VPWR VGND sg13g2_fill_1
XFILLER_32_1017 VPWR VGND sg13g2_fill_2
XFILLER_21_962 VPWR VGND sg13g2_decap_8
XFILLER_20_494 VPWR VGND sg13g2_decap_8
XFILLER_4_638 VPWR VGND sg13g2_decap_8
XFILLER_3_148 VPWR VGND sg13g2_decap_8
XFILLER_0_833 VPWR VGND sg13g2_decap_8
XdigitalH.g\[26\].u.inv VPWR digitalH.g\[26\].u.OUTN net30 VGND sg13g2_inv_1
XFILLER_48_826 VPWR VGND sg13g2_decap_8
XFILLER_47_336 VPWR VGND sg13g2_decap_8
XFILLER_16_701 VPWR VGND sg13g2_decap_8
XFILLER_28_550 VPWR VGND sg13g2_decap_8
XFILLER_15_211 VPWR VGND sg13g2_decap_8
XFILLER_43_553 VPWR VGND sg13g2_decap_8
XFILLER_31_704 VPWR VGND sg13g2_decap_8
XFILLER_15_288 VPWR VGND sg13g2_decap_8
XFILLER_30_214 VPWR VGND sg13g2_decap_8
XFILLER_8_922 VPWR VGND sg13g2_fill_1
XFILLER_7_421 VPWR VGND sg13g2_decap_8
XFILLER_7_498 VPWR VGND sg13g2_decap_8
XFILLER_24_4 VPWR VGND sg13g2_decap_8
XFILLER_38_336 VPWR VGND sg13g2_decap_8
XFILLER_0_1015 VPWR VGND sg13g2_decap_8
XFILLER_19_583 VPWR VGND sg13g2_decap_8
XFILLER_0_84 VPWR VGND sg13g2_decap_8
XFILLER_34_553 VPWR VGND sg13g2_decap_8
XFILLER_22_704 VPWR VGND sg13g2_decap_8
XFILLER_21_214 VPWR VGND sg13g2_decap_8
XFILLER_9_71 VPWR VGND sg13g2_decap_8
XdigitalL.g\[66\].u.buff net110 digitalL.g\[66\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_30_792 VPWR VGND sg13g2_fill_2
XFILLER_30_781 VPWR VGND sg13g2_decap_8
XFILLER_28_25 VPWR VGND sg13g2_decap_8
XFILLER_29_347 VPWR VGND sg13g2_decap_8
XFILLER_44_35 VPWR VGND sg13g2_decap_8
XFILLER_13_715 VPWR VGND sg13g2_decap_8
XFILLER_25_564 VPWR VGND sg13g2_decap_8
XFILLER_12_214 VPWR VGND sg13g2_decap_8
XFILLER_9_708 VPWR VGND sg13g2_decap_8
XFILLER_8_218 VPWR VGND sg13g2_decap_8
XFILLER_40_567 VPWR VGND sg13g2_decap_8
XFILLER_21_792 VPWR VGND sg13g2_decap_8
XFILLER_20_291 VPWR VGND sg13g2_decap_8
XFILLER_5_925 VPWR VGND sg13g2_decap_8
XFILLER_4_435 VPWR VGND sg13g2_decap_8
XFILLER_5_29 VPWR VGND sg13g2_decap_8
XFILLER_0_630 VPWR VGND sg13g2_decap_8
XFILLER_48_623 VPWR VGND sg13g2_decap_8
XdigitalH.g\[9\].u.inv VPWR digitalH.g\[9\].u.OUTN net38 VGND sg13g2_inv_1
XFILLER_47_133 VPWR VGND sg13g2_decap_8
XFILLER_16_575 VPWR VGND sg13g2_decap_8
XFILLER_43_350 VPWR VGND sg13g2_decap_8
XFILLER_31_501 VPWR VGND sg13g2_decap_8
XdigitalL.g\[81\].u.inv VPWR digitalL.g\[81\].u.OUTN net101 VGND sg13g2_inv_1
XFILLER_31_578 VPWR VGND sg13g2_decap_8
XFILLER_8_752 VPWR VGND sg13g2_fill_1
XFILLER_7_295 VPWR VGND sg13g2_decap_8
XFILLER_39_623 VPWR VGND sg13g2_decap_8
XFILLER_22_1005 VPWR VGND sg13g2_decap_8
XFILLER_38_133 VPWR VGND sg13g2_decap_8
XFILLER_19_380 VPWR VGND sg13g2_decap_8
XFILLER_34_350 VPWR VGND sg13g2_decap_8
XFILLER_22_501 VPWR VGND sg13g2_decap_8
XFILLER_22_578 VPWR VGND sg13g2_decap_8
XdigitalH.g\[57\].u.buff net52 digitalH.g\[57\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_939 VPWR VGND sg13g2_decap_8
XFILLER_1_427 VPWR VGND sg13g2_decap_8
XFILLER_39_35 VPWR VGND sg13g2_decap_8
XFILLER_29_144 VPWR VGND sg13g2_decap_8
XFILLER_45_637 VPWR VGND sg13g2_decap_8
XFILLER_44_147 VPWR VGND sg13g2_decap_8
XFILLER_26_851 VPWR VGND sg13g2_decap_8
XFILLER_25_361 VPWR VGND sg13g2_decap_8
XFILLER_13_512 VPWR VGND sg13g2_decap_8
XFILLER_9_505 VPWR VGND sg13g2_decap_8
XFILLER_13_589 VPWR VGND sg13g2_decap_8
XFILLER_40_364 VPWR VGND sg13g2_decap_8
XFILLER_5_722 VPWR VGND sg13g2_decap_8
XFILLER_4_232 VPWR VGND sg13g2_decap_8
XFILLER_5_799 VPWR VGND sg13g2_decap_8
XdigitalL.g\[28\].u.inv VPWR digitalL.g\[28\].u.OUTN net83 VGND sg13g2_inv_1
XFILLER_20_81 VPWR VGND sg13g2_decap_8
XFILLER_49_910 VPWR VGND sg13g2_decap_8
XFILLER_48_420 VPWR VGND sg13g2_decap_8
XFILLER_1_994 VPWR VGND sg13g2_decap_8
XFILLER_49_987 VPWR VGND sg13g2_decap_8
XFILLER_36_637 VPWR VGND sg13g2_decap_8
XFILLER_48_497 VPWR VGND sg13g2_decap_8
XFILLER_35_147 VPWR VGND sg13g2_decap_8
XFILLER_16_372 VPWR VGND sg13g2_decap_8
XFILLER_32_887 VPWR VGND sg13g2_fill_2
XFILLER_31_375 VPWR VGND sg13g2_decap_8
XFILLER_8_582 VPWR VGND sg13g2_decap_8
XFILLER_6_50 VPWR VGND sg13g2_decap_8
XFILLER_6_1021 VPWR VGND sg13g2_decap_8
XFILLER_39_420 VPWR VGND sg13g2_decap_8
XFILLER_39_497 VPWR VGND sg13g2_decap_8
XFILLER_27_637 VPWR VGND sg13g2_decap_8
XFILLER_14_309 VPWR VGND sg13g2_decap_8
XdigitalL.g\[81\].u.buff net100 digitalL.g\[81\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_26_158 VPWR VGND sg13g2_decap_8
XdigitalL.g\[10\].u.buff net72 digitalL.g\[10\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_23_865 VPWR VGND sg13g2_decap_8
XFILLER_41_14 VPWR VGND sg13g2_decap_8
XFILLER_22_375 VPWR VGND sg13g2_decap_8
XFILLER_10_537 VPWR VGND sg13g2_decap_8
XFILLER_6_519 VPWR VGND sg13g2_decap_8
XdigitalH.g\[5\].u.buff net24 digitalH.g\[5\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[104\].u.buff net40 digitalH.g\[104\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_736 VPWR VGND sg13g2_decap_8
XFILLER_1_224 VPWR VGND sg13g2_decap_8
XFILLER_49_217 VPWR VGND sg13g2_decap_8
XFILLER_46_924 VPWR VGND sg13g2_decap_8
XFILLER_45_434 VPWR VGND sg13g2_decap_8
XFILLER_18_659 VPWR VGND sg13g2_decap_8
XFILLER_17_169 VPWR VGND sg13g2_decap_8
XFILLER_41_651 VPWR VGND sg13g2_decap_8
XFILLER_13_386 VPWR VGND sg13g2_decap_8
XFILLER_15_92 VPWR VGND sg13g2_decap_8
XFILLER_9_302 VPWR VGND sg13g2_decap_8
XFILLER_40_161 VPWR VGND sg13g2_decap_8
XFILLER_9_379 VPWR VGND sg13g2_decap_8
XFILLER_5_596 VPWR VGND sg13g2_decap_8
XdigitalL.g\[124\].u.inv VPWR digitalL.g\[124\].u.OUTN net69 VGND sg13g2_inv_1
XdigitalH.g\[74\].u.inv VPWR digitalH.g\[74\].u.OUTN net61 VGND sg13g2_inv_1
XFILLER_1_791 VPWR VGND sg13g2_decap_8
XFILLER_49_784 VPWR VGND sg13g2_decap_8
XFILLER_48_294 VPWR VGND sg13g2_decap_8
XFILLER_36_434 VPWR VGND sg13g2_decap_8
XFILLER_32_662 VPWR VGND sg13g2_decap_8
XFILLER_31_172 VPWR VGND sg13g2_decap_8
XFILLER_20_857 VPWR VGND sg13g2_fill_2
XFILLER_28_935 VPWR VGND sg13g2_decap_8
XFILLER_39_294 VPWR VGND sg13g2_decap_8
XFILLER_36_14 VPWR VGND sg13g2_decap_8
XFILLER_27_434 VPWR VGND sg13g2_decap_8
XFILLER_14_106 VPWR VGND sg13g2_decap_8
XFILLER_42_448 VPWR VGND sg13g2_decap_8
XdigitalH.g\[72\].u.buff net61 digitalH.g\[72\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_23_662 VPWR VGND sg13g2_decap_8
XFILLER_10_334 VPWR VGND sg13g2_decap_8
XFILLER_7_806 VPWR VGND sg13g2_decap_4
XFILLER_22_172 VPWR VGND sg13g2_decap_8
XFILLER_6_316 VPWR VGND sg13g2_decap_8
XFILLER_2_533 VPWR VGND sg13g2_decap_8
XFILLER_46_721 VPWR VGND sg13g2_decap_8
XFILLER_45_231 VPWR VGND sg13g2_decap_8
XFILLER_18_456 VPWR VGND sg13g2_decap_8
XFILLER_46_798 VPWR VGND sg13g2_decap_8
XFILLER_33_448 VPWR VGND sg13g2_decap_8
XFILLER_14_673 VPWR VGND sg13g2_decap_8
XFILLER_20_109 VPWR VGND sg13g2_decap_8
XFILLER_13_183 VPWR VGND sg13g2_decap_8
XFILLER_9_176 VPWR VGND sg13g2_decap_8
XFILLER_6_894 VPWR VGND sg13g2_decap_8
XFILLER_5_393 VPWR VGND sg13g2_decap_8
XFILLER_3_1002 VPWR VGND sg13g2_decap_8
XFILLER_49_581 VPWR VGND sg13g2_decap_8
XFILLER_37_721 VPWR VGND sg13g2_decap_8
XFILLER_36_231 VPWR VGND sg13g2_decap_8
XFILLER_25_949 VPWR VGND sg13g2_decap_8
XFILLER_18_990 VPWR VGND sg13g2_fill_2
XFILLER_24_459 VPWR VGND sg13g2_decap_8
XFILLER_20_676 VPWR VGND sg13g2_decap_8
Xfanout111 net112 net111 VPWR VGND sg13g2_buf_1
Xfanout100 net101 net100 VPWR VGND sg13g2_buf_1
XFILLER_47_518 VPWR VGND sg13g2_decap_8
XFILLER_47_35 VPWR VGND sg13g2_decap_8
XFILLER_28_732 VPWR VGND sg13g2_decap_8
XFILLER_27_231 VPWR VGND sg13g2_decap_8
XFILLER_43_735 VPWR VGND sg13g2_decap_8
XFILLER_42_245 VPWR VGND sg13g2_decap_8
XFILLER_11_610 VPWR VGND sg13g2_decap_8
XFILLER_8_29 VPWR VGND sg13g2_decap_8
XdigitalH.g\[22\].u.inv VPWR digitalH.g\[22\].u.OUTN net28 VGND sg13g2_inv_1
XFILLER_10_131 VPWR VGND sg13g2_decap_8
XFILLER_7_603 VPWR VGND sg13g2_decap_8
XFILLER_11_687 VPWR VGND sg13g2_decap_8
XFILLER_6_113 VPWR VGND sg13g2_decap_8
XFILLER_12_60 VPWR VGND sg13g2_decap_8
XFILLER_3_820 VPWR VGND sg13g2_decap_8
XFILLER_2_330 VPWR VGND sg13g2_decap_8
XFILLER_3_897 VPWR VGND sg13g2_decap_8
X_11_ net68 net13 VPWR VGND sg13g2_buf_1
XFILLER_38_518 VPWR VGND sg13g2_decap_8
XFILLER_46_595 VPWR VGND sg13g2_decap_8
XFILLER_18_253 VPWR VGND sg13g2_decap_8
XFILLER_33_245 VPWR VGND sg13g2_decap_8
XFILLER_14_470 VPWR VGND sg13g2_decap_8
XFILLER_6_680 VPWR VGND sg13g2_decap_8
XFILLER_5_190 VPWR VGND sg13g2_decap_8
XFILLER_45_0 VPWR VGND sg13g2_decap_8
XdigitalL.g\[76\].u.inv VPWR digitalL.g\[76\].u.OUTN net107 VGND sg13g2_inv_1
XFILLER_29_529 VPWR VGND sg13g2_decap_8
XFILLER_37_595 VPWR VGND sg13g2_decap_8
XFILLER_25_746 VPWR VGND sg13g2_decap_8
XFILLER_24_256 VPWR VGND sg13g2_decap_8
XFILLER_21_941 VPWR VGND sg13g2_decap_8
XFILLER_20_473 VPWR VGND sg13g2_decap_8
XFILLER_4_617 VPWR VGND sg13g2_decap_8
XFILLER_3_127 VPWR VGND sg13g2_decap_8
XFILLER_0_812 VPWR VGND sg13g2_decap_8
XFILLER_0_889 VPWR VGND sg13g2_decap_8
XFILLER_48_805 VPWR VGND sg13g2_decap_8
XFILLER_47_315 VPWR VGND sg13g2_decap_8
XFILLER_16_735 VPWR VGND sg13g2_fill_1
XFILLER_43_532 VPWR VGND sg13g2_decap_8
XFILLER_15_267 VPWR VGND sg13g2_decap_8
XFILLER_11_484 VPWR VGND sg13g2_decap_8
XFILLER_7_400 VPWR VGND sg13g2_decap_8
XFILLER_23_81 VPWR VGND sg13g2_decap_8
XdigitalH.g\[5\].u.inv VPWR digitalH.g\[5\].u.OUTN net24 VGND sg13g2_inv_1
XFILLER_7_477 VPWR VGND sg13g2_decap_8
XFILLER_3_694 VPWR VGND sg13g2_decap_8
XFILLER_38_315 VPWR VGND sg13g2_decap_8
XFILLER_47_882 VPWR VGND sg13g2_decap_8
XFILLER_19_562 VPWR VGND sg13g2_decap_8
XFILLER_0_63 VPWR VGND sg13g2_decap_8
XFILLER_46_392 VPWR VGND sg13g2_decap_8
XFILLER_34_532 VPWR VGND sg13g2_decap_8
XFILLER_9_50 VPWR VGND sg13g2_decap_8
XFILLER_30_760 VPWR VGND sg13g2_decap_8
XdigitalL.g\[35\].u.buff net92 digitalL.g\[35\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_1_609 VPWR VGND sg13g2_decap_8
XFILLER_0_119 VPWR VGND sg13g2_decap_8
XdigitalL.g\[0\].u.buff net70 digitalL.g\[0\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_326 VPWR VGND sg13g2_decap_8
XFILLER_45_819 VPWR VGND sg13g2_decap_8
XFILLER_44_329 VPWR VGND sg13g2_decap_8
XFILLER_44_14 VPWR VGND sg13g2_decap_8
XFILLER_37_392 VPWR VGND sg13g2_decap_8
XFILLER_25_543 VPWR VGND sg13g2_decap_8
XFILLER_13_738 VPWR VGND sg13g2_fill_1
XFILLER_40_546 VPWR VGND sg13g2_decap_8
XFILLER_21_771 VPWR VGND sg13g2_decap_8
XFILLER_21_760 VPWR VGND sg13g2_decap_8
XFILLER_5_904 VPWR VGND sg13g2_decap_8
XFILLER_20_270 VPWR VGND sg13g2_decap_8
XFILLER_4_414 VPWR VGND sg13g2_decap_8
XFILLER_48_602 VPWR VGND sg13g2_decap_8
XFILLER_0_686 VPWR VGND sg13g2_decap_8
XFILLER_47_112 VPWR VGND sg13g2_decap_8
XFILLER_48_679 VPWR VGND sg13g2_decap_8
XFILLER_47_189 VPWR VGND sg13g2_decap_8
XFILLER_35_329 VPWR VGND sg13g2_decap_8
XFILLER_29_893 VPWR VGND sg13g2_decap_8
XFILLER_18_92 VPWR VGND sg13g2_decap_8
XFILLER_16_554 VPWR VGND sg13g2_decap_8
XFILLER_44_885 VPWR VGND sg13g2_decap_8
XdigitalL.g\[24\].u.inv VPWR digitalL.g\[24\].u.OUTN net82 VGND sg13g2_inv_1
XFILLER_34_91 VPWR VGND sg13g2_decap_8
XFILLER_31_557 VPWR VGND sg13g2_decap_8
XFILLER_11_281 VPWR VGND sg13g2_decap_8
XFILLER_7_274 VPWR VGND sg13g2_decap_8
XFILLER_4_981 VPWR VGND sg13g2_decap_8
XFILLER_3_491 VPWR VGND sg13g2_decap_8
XFILLER_39_602 VPWR VGND sg13g2_decap_8
XFILLER_38_112 VPWR VGND sg13g2_decap_8
XFILLER_27_819 VPWR VGND sg13g2_decap_8
XFILLER_22_1028 VPWR VGND sg13g2_fill_1
XFILLER_39_679 VPWR VGND sg13g2_decap_8
XFILLER_38_189 VPWR VGND sg13g2_decap_8
XdigitalL.g\[119\].u.inv VPWR digitalL.g\[119\].u.OUTN net77 VGND sg13g2_inv_1
XFILLER_22_557 VPWR VGND sg13g2_decap_8
XFILLER_10_719 VPWR VGND sg13g2_decap_8
XdigitalH.g\[69\].u.inv VPWR digitalH.g\[69\].u.OUTN net62 VGND sg13g2_inv_1
XdigitalL.g\[119\].u.buff net76 digitalL.g\[119\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[97\].u.buff net42 digitalH.g\[97\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_918 VPWR VGND sg13g2_decap_8
XFILLER_1_406 VPWR VGND sg13g2_decap_8
XFILLER_39_14 VPWR VGND sg13g2_decap_8
XdigitalH.g\[26\].u.buff net30 digitalH.g\[26\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_123 VPWR VGND sg13g2_decap_8
XFILLER_45_616 VPWR VGND sg13g2_decap_8
XFILLER_44_126 VPWR VGND sg13g2_decap_8
XFILLER_26_830 VPWR VGND sg13g2_decap_8
XFILLER_25_340 VPWR VGND sg13g2_decap_8
XFILLER_13_568 VPWR VGND sg13g2_decap_8
XFILLER_40_343 VPWR VGND sg13g2_decap_8
XFILLER_5_701 VPWR VGND sg13g2_decap_8
XFILLER_4_211 VPWR VGND sg13g2_decap_8
XFILLER_5_778 VPWR VGND sg13g2_decap_8
XFILLER_20_60 VPWR VGND sg13g2_decap_8
XFILLER_4_288 VPWR VGND sg13g2_decap_8
XFILLER_1_973 VPWR VGND sg13g2_decap_8
XFILLER_0_483 VPWR VGND sg13g2_decap_8
XFILLER_49_966 VPWR VGND sg13g2_decap_8
XFILLER_48_476 VPWR VGND sg13g2_decap_8
XFILLER_36_616 VPWR VGND sg13g2_decap_8
XFILLER_35_126 VPWR VGND sg13g2_decap_8
XFILLER_29_690 VPWR VGND sg13g2_decap_8
XFILLER_16_351 VPWR VGND sg13g2_decap_8
XdigitalL.g\[120\].u.inv VPWR digitalL.g\[120\].u.OUTN net77 VGND sg13g2_inv_1
XFILLER_44_693 VPWR VGND sg13g2_decap_8
XFILLER_32_811 VPWR VGND sg13g2_fill_2
XFILLER_32_866 VPWR VGND sg13g2_fill_1
XdigitalH.g\[70\].u.inv VPWR digitalH.g\[70\].u.OUTN net62 VGND sg13g2_inv_1
XFILLER_31_354 VPWR VGND sg13g2_decap_8
XFILLER_8_561 VPWR VGND sg13g2_decap_8
XFILLER_6_1000 VPWR VGND sg13g2_decap_8
XFILLER_39_476 VPWR VGND sg13g2_decap_8
XFILLER_27_616 VPWR VGND sg13g2_decap_8
XFILLER_26_137 VPWR VGND sg13g2_decap_8
XFILLER_35_693 VPWR VGND sg13g2_decap_8
XFILLER_23_844 VPWR VGND sg13g2_decap_8
XFILLER_10_516 VPWR VGND sg13g2_decap_8
XFILLER_22_354 VPWR VGND sg13g2_decap_8
XdigitalL.g\[50\].u.buff net102 digitalL.g\[50\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_715 VPWR VGND sg13g2_decap_8
XFILLER_1_203 VPWR VGND sg13g2_decap_8
XFILLER_46_903 VPWR VGND sg13g2_decap_8
XFILLER_45_413 VPWR VGND sg13g2_decap_8
XFILLER_18_638 VPWR VGND sg13g2_decap_8
XFILLER_17_148 VPWR VGND sg13g2_decap_8
XFILLER_41_630 VPWR VGND sg13g2_decap_8
XFILLER_13_365 VPWR VGND sg13g2_decap_8
XFILLER_15_71 VPWR VGND sg13g2_decap_8
XFILLER_40_140 VPWR VGND sg13g2_decap_8
XFILLER_9_358 VPWR VGND sg13g2_decap_8
XFILLER_31_81 VPWR VGND sg13g2_decap_8
XFILLER_49_7 VPWR VGND sg13g2_decap_8
XFILLER_5_575 VPWR VGND sg13g2_decap_8
XdigitalH.g\[17\].u.inv VPWR digitalH.g\[17\].u.OUTN net27 VGND sg13g2_inv_1
XFILLER_1_770 VPWR VGND sg13g2_decap_8
XFILLER_0_280 VPWR VGND sg13g2_decap_8
XFILLER_49_763 VPWR VGND sg13g2_decap_8
XFILLER_48_273 VPWR VGND sg13g2_decap_8
XFILLER_36_413 VPWR VGND sg13g2_decap_8
XFILLER_45_980 VPWR VGND sg13g2_decap_8
XFILLER_44_490 VPWR VGND sg13g2_decap_8
XFILLER_32_641 VPWR VGND sg13g2_decap_8
XFILLER_31_151 VPWR VGND sg13g2_decap_8
XFILLER_20_825 VPWR VGND sg13g2_fill_1
XFILLER_20_847 VPWR VGND sg13g2_fill_2
XFILLER_20_836 VPWR VGND sg13g2_fill_1
XFILLER_11_29 VPWR VGND sg13g2_decap_8
XFILLER_28_1012 VPWR VGND sg13g2_decap_8
XFILLER_28_914 VPWR VGND sg13g2_decap_8
XFILLER_39_273 VPWR VGND sg13g2_decap_8
XFILLER_27_413 VPWR VGND sg13g2_decap_8
XFILLER_42_427 VPWR VGND sg13g2_decap_8
XFILLER_35_490 VPWR VGND sg13g2_decap_8
XFILLER_23_641 VPWR VGND sg13g2_decap_8
XFILLER_22_151 VPWR VGND sg13g2_decap_8
XFILLER_10_313 VPWR VGND sg13g2_decap_8
XdigitalH.g\[41\].u.buff net47 digitalH.g\[41\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_512 VPWR VGND sg13g2_decap_8
XFILLER_2_589 VPWR VGND sg13g2_decap_8
XFILLER_46_700 VPWR VGND sg13g2_decap_8
XFILLER_45_210 VPWR VGND sg13g2_decap_8
XFILLER_18_435 VPWR VGND sg13g2_decap_8
XFILLER_46_777 VPWR VGND sg13g2_decap_8
XFILLER_45_287 VPWR VGND sg13g2_decap_8
XFILLER_33_427 VPWR VGND sg13g2_decap_8
XFILLER_27_980 VPWR VGND sg13g2_decap_8
XFILLER_26_81 VPWR VGND sg13g2_decap_8
XFILLER_14_652 VPWR VGND sg13g2_decap_8
XFILLER_13_162 VPWR VGND sg13g2_decap_8
XFILLER_9_155 VPWR VGND sg13g2_decap_8
XFILLER_42_91 VPWR VGND sg13g2_decap_8
XFILLER_6_851 VPWR VGND sg13g2_fill_2
XFILLER_5_372 VPWR VGND sg13g2_decap_8
XFILLER_49_560 VPWR VGND sg13g2_decap_8
XFILLER_3_85 VPWR VGND sg13g2_decap_8
XFILLER_37_700 VPWR VGND sg13g2_decap_8
XFILLER_36_210 VPWR VGND sg13g2_decap_8
XFILLER_36_287 VPWR VGND sg13g2_decap_8
XFILLER_25_928 VPWR VGND sg13g2_decap_8
XFILLER_24_438 VPWR VGND sg13g2_decap_8
XdigitalL.g\[72\].u.inv VPWR digitalL.g\[72\].u.OUTN net108 VGND sg13g2_inv_1
XFILLER_22_39 VPWR VGND sg13g2_decap_8
XFILLER_20_655 VPWR VGND sg13g2_decap_8
XFILLER_3_309 VPWR VGND sg13g2_decap_8
Xfanout112 net113 net112 VPWR VGND sg13g2_buf_1
Xfanout101 net113 net101 VPWR VGND sg13g2_buf_1
XFILLER_47_14 VPWR VGND sg13g2_decap_8
XFILLER_28_711 VPWR VGND sg13g2_decap_8
XFILLER_27_210 VPWR VGND sg13g2_decap_8
XFILLER_43_714 VPWR VGND sg13g2_decap_8
XFILLER_28_788 VPWR VGND sg13g2_decap_8
XFILLER_15_449 VPWR VGND sg13g2_decap_8
XFILLER_42_224 VPWR VGND sg13g2_decap_8
XFILLER_27_287 VPWR VGND sg13g2_decap_8
XFILLER_10_110 VPWR VGND sg13g2_decap_8
XFILLER_11_666 VPWR VGND sg13g2_decap_8
XFILLER_10_187 VPWR VGND sg13g2_decap_8
XFILLER_7_659 VPWR VGND sg13g2_decap_8
XFILLER_6_169 VPWR VGND sg13g2_decap_8
XFILLER_3_876 VPWR VGND sg13g2_decap_8
XFILLER_2_386 VPWR VGND sg13g2_decap_8
X_10_ net115 net12 VPWR VGND sg13g2_buf_1
XdigitalH.g\[1\].u.inv VPWR digitalH.g\[1\].u.OUTN net21 VGND sg13g2_inv_1
XFILLER_19_744 VPWR VGND sg13g2_decap_8
XFILLER_18_232 VPWR VGND sg13g2_decap_8
XFILLER_46_574 VPWR VGND sg13g2_decap_8
XFILLER_37_91 VPWR VGND sg13g2_decap_8
XFILLER_34_714 VPWR VGND sg13g2_decap_8
XFILLER_19_777 VPWR VGND sg13g2_fill_1
XFILLER_33_224 VPWR VGND sg13g2_decap_8
XFILLER_18_1011 VPWR VGND sg13g2_fill_2
XFILLER_30_975 VPWR VGND sg13g2_decap_8
XFILLER_30_953 VPWR VGND sg13g2_decap_4
XFILLER_30_986 VPWR VGND sg13g2_fill_1
XdigitalL.g\[19\].u.inv VPWR digitalL.g\[19\].u.OUTN net81 VGND sg13g2_inv_1
XFILLER_38_0 VPWR VGND sg13g2_decap_8
XFILLER_29_508 VPWR VGND sg13g2_decap_8
XFILLER_25_1026 VPWR VGND sg13g2_fill_2
XFILLER_37_574 VPWR VGND sg13g2_decap_8
XFILLER_25_725 VPWR VGND sg13g2_decap_8
XFILLER_24_235 VPWR VGND sg13g2_decap_8
XFILLER_33_49 VPWR VGND sg13g2_decap_8
XFILLER_21_920 VPWR VGND sg13g2_decap_8
XFILLER_32_1008 VPWR VGND sg13g2_fill_2
XFILLER_21_997 VPWR VGND sg13g2_decap_8
XFILLER_20_452 VPWR VGND sg13g2_decap_8
XFILLER_3_106 VPWR VGND sg13g2_decap_8
XFILLER_0_868 VPWR VGND sg13g2_decap_8
XFILLER_43_511 VPWR VGND sg13g2_decap_8
XFILLER_28_585 VPWR VGND sg13g2_decap_8
XFILLER_15_246 VPWR VGND sg13g2_decap_8
XFILLER_43_588 VPWR VGND sg13g2_decap_8
XFILLER_31_739 VPWR VGND sg13g2_decap_8
XFILLER_30_249 VPWR VGND sg13g2_decap_8
XFILLER_11_463 VPWR VGND sg13g2_decap_8
XFILLER_23_60 VPWR VGND sg13g2_decap_8
XFILLER_7_456 VPWR VGND sg13g2_decap_8
XFILLER_48_1015 VPWR VGND sg13g2_decap_8
XdigitalL.g\[20\].u.inv VPWR digitalL.g\[20\].u.OUTN net81 VGND sg13g2_inv_1
XFILLER_3_673 VPWR VGND sg13g2_decap_8
XFILLER_2_183 VPWR VGND sg13g2_decap_8
XFILLER_19_541 VPWR VGND sg13g2_decap_8
XFILLER_0_42 VPWR VGND sg13g2_decap_8
XFILLER_47_861 VPWR VGND sg13g2_decap_8
XFILLER_46_371 VPWR VGND sg13g2_decap_8
XFILLER_34_511 VPWR VGND sg13g2_decap_8
XFILLER_34_588 VPWR VGND sg13g2_decap_8
XFILLER_22_739 VPWR VGND sg13g2_decap_8
XFILLER_21_249 VPWR VGND sg13g2_decap_8
XdigitalL.g\[115\].u.inv VPWR digitalL.g\[115\].u.OUTN net78 VGND sg13g2_inv_1
XdigitalL.g\[75\].u.buff net107 digitalL.g\[75\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[65\].u.inv VPWR digitalH.g\[65\].u.OUTN net63 VGND sg13g2_inv_1
XFILLER_29_305 VPWR VGND sg13g2_decap_8
XFILLER_44_308 VPWR VGND sg13g2_decap_8
XFILLER_37_371 VPWR VGND sg13g2_decap_8
XFILLER_25_522 VPWR VGND sg13g2_decap_8
XFILLER_40_525 VPWR VGND sg13g2_decap_8
XFILLER_25_599 VPWR VGND sg13g2_decap_8
XFILLER_12_249 VPWR VGND sg13g2_decap_8
XFILLER_0_665 VPWR VGND sg13g2_decap_8
XFILLER_48_658 VPWR VGND sg13g2_decap_8
XFILLER_47_168 VPWR VGND sg13g2_decap_8
XFILLER_35_308 VPWR VGND sg13g2_decap_8
XFILLER_29_872 VPWR VGND sg13g2_decap_8
XFILLER_18_71 VPWR VGND sg13g2_decap_8
XFILLER_16_533 VPWR VGND sg13g2_decap_8
XFILLER_44_820 VPWR VGND sg13g2_decap_4
XFILLER_28_382 VPWR VGND sg13g2_decap_8
XFILLER_44_864 VPWR VGND sg13g2_decap_8
XFILLER_43_385 VPWR VGND sg13g2_decap_8
XFILLER_31_536 VPWR VGND sg13g2_decap_8
XFILLER_34_70 VPWR VGND sg13g2_decap_8
XFILLER_11_260 VPWR VGND sg13g2_decap_8
XFILLER_7_253 VPWR VGND sg13g2_decap_8
XFILLER_8_787 VPWR VGND sg13g2_fill_1
XFILLER_4_960 VPWR VGND sg13g2_decap_8
XFILLER_3_470 VPWR VGND sg13g2_decap_8
XFILLER_39_658 VPWR VGND sg13g2_decap_8
XFILLER_38_168 VPWR VGND sg13g2_decap_8
XFILLER_26_319 VPWR VGND sg13g2_decap_8
XFILLER_34_385 VPWR VGND sg13g2_decap_8
XFILLER_14_29 VPWR VGND sg13g2_decap_8
XFILLER_22_536 VPWR VGND sg13g2_decap_8
XFILLER_30_39 VPWR VGND sg13g2_decap_8
XFILLER_29_102 VPWR VGND sg13g2_decap_8
XdigitalH.g\[66\].u.buff net63 digitalH.g\[66\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_29_179 VPWR VGND sg13g2_decap_8
XFILLER_44_105 VPWR VGND sg13g2_decap_8
XFILLER_26_886 VPWR VGND sg13g2_decap_8
XFILLER_13_547 VPWR VGND sg13g2_decap_8
XFILLER_40_322 VPWR VGND sg13g2_decap_8
XFILLER_25_396 VPWR VGND sg13g2_decap_8
XFILLER_40_399 VPWR VGND sg13g2_decap_8
XFILLER_5_757 VPWR VGND sg13g2_decap_8
XFILLER_4_267 VPWR VGND sg13g2_decap_8
XFILLER_1_952 VPWR VGND sg13g2_decap_8
XFILLER_0_462 VPWR VGND sg13g2_decap_8
XFILLER_49_945 VPWR VGND sg13g2_decap_8
XFILLER_48_455 VPWR VGND sg13g2_decap_8
XFILLER_29_81 VPWR VGND sg13g2_decap_8
XFILLER_35_105 VPWR VGND sg13g2_decap_8
XFILLER_16_330 VPWR VGND sg13g2_decap_8
XFILLER_45_91 VPWR VGND sg13g2_decap_8
XFILLER_44_672 VPWR VGND sg13g2_decap_8
XFILLER_43_182 VPWR VGND sg13g2_decap_8
XFILLER_32_845 VPWR VGND sg13g2_fill_1
XFILLER_31_333 VPWR VGND sg13g2_decap_8
XdigitalH.g\[13\].u.inv VPWR digitalH.g\[13\].u.OUTN net26 VGND sg13g2_inv_1
XFILLER_8_540 VPWR VGND sg13g2_decap_8
XFILLER_6_85 VPWR VGND sg13g2_decap_8
XFILLER_39_455 VPWR VGND sg13g2_decap_8
XFILLER_26_116 VPWR VGND sg13g2_decap_8
XFILLER_42_609 VPWR VGND sg13g2_decap_8
XFILLER_41_119 VPWR VGND sg13g2_decap_8
XFILLER_35_672 VPWR VGND sg13g2_decap_8
XFILLER_25_39 VPWR VGND sg13g2_decap_8
XFILLER_23_823 VPWR VGND sg13g2_decap_8
XFILLER_34_182 VPWR VGND sg13g2_decap_8
XFILLER_22_333 VPWR VGND sg13g2_decap_8
XFILLER_41_49 VPWR VGND sg13g2_decap_8
XdigitalL.g\[90\].u.buff net98 digitalL.g\[90\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_1_259 VPWR VGND sg13g2_decap_8
XdigitalL.g\[67\].u.inv VPWR digitalL.g\[67\].u.OUTN net110 VGND sg13g2_inv_1
XFILLER_18_617 VPWR VGND sg13g2_decap_8
XFILLER_17_127 VPWR VGND sg13g2_decap_8
XdigitalH.g\[113\].u.buff net36 digitalH.g\[113\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_959 VPWR VGND sg13g2_decap_8
XFILLER_45_469 VPWR VGND sg13g2_decap_8
XFILLER_33_609 VPWR VGND sg13g2_decap_8
XFILLER_26_683 VPWR VGND sg13g2_decap_8
XFILLER_15_50 VPWR VGND sg13g2_decap_8
XFILLER_25_193 VPWR VGND sg13g2_decap_8
XFILLER_13_344 VPWR VGND sg13g2_decap_8
XFILLER_41_686 VPWR VGND sg13g2_decap_8
XFILLER_9_337 VPWR VGND sg13g2_decap_8
XFILLER_40_196 VPWR VGND sg13g2_decap_8
XFILLER_31_60 VPWR VGND sg13g2_decap_8
XFILLER_5_554 VPWR VGND sg13g2_decap_8
XFILLER_49_742 VPWR VGND sg13g2_decap_8
XFILLER_48_252 VPWR VGND sg13g2_decap_8
XFILLER_36_469 VPWR VGND sg13g2_decap_8
XFILLER_17_694 VPWR VGND sg13g2_decap_8
XFILLER_32_620 VPWR VGND sg13g2_decap_8
XFILLER_31_130 VPWR VGND sg13g2_decap_8
XFILLER_32_697 VPWR VGND sg13g2_decap_8
XFILLER_39_252 VPWR VGND sg13g2_decap_8
XFILLER_36_49 VPWR VGND sg13g2_decap_8
XFILLER_27_469 VPWR VGND sg13g2_decap_8
XFILLER_42_406 VPWR VGND sg13g2_decap_8
XFILLER_23_620 VPWR VGND sg13g2_decap_8
XFILLER_22_130 VPWR VGND sg13g2_decap_8
XFILLER_23_697 VPWR VGND sg13g2_decap_8
XFILLER_10_369 VPWR VGND sg13g2_decap_8
XdigitalL.g\[103\].u.buff net87 digitalL.g\[103\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[81\].u.buff net58 digitalH.g\[81\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalH.g\[10\].u.buff net24 digitalH.g\[10\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_2_568 VPWR VGND sg13g2_decap_8
XFILLER_19_937 VPWR VGND sg13g2_fill_1
XFILLER_18_414 VPWR VGND sg13g2_decap_8
XFILLER_46_756 VPWR VGND sg13g2_decap_8
XFILLER_45_266 VPWR VGND sg13g2_decap_8
XFILLER_33_406 VPWR VGND sg13g2_decap_8
XFILLER_26_60 VPWR VGND sg13g2_decap_8
XFILLER_14_631 VPWR VGND sg13g2_decap_8
XFILLER_26_480 VPWR VGND sg13g2_decap_8
XFILLER_13_141 VPWR VGND sg13g2_decap_8
XFILLER_9_134 VPWR VGND sg13g2_decap_8
XdigitalL.g\[8\].u.inv VPWR digitalL.g\[8\].u.OUTN net72 VGND sg13g2_inv_1
XFILLER_41_483 VPWR VGND sg13g2_decap_8
XFILLER_42_70 VPWR VGND sg13g2_decap_8
XFILLER_6_830 VPWR VGND sg13g2_fill_2
XFILLER_5_351 VPWR VGND sg13g2_decap_8
XFILLER_3_64 VPWR VGND sg13g2_decap_8
XFILLER_25_907 VPWR VGND sg13g2_decap_8
XFILLER_36_266 VPWR VGND sg13g2_decap_8
XFILLER_24_417 VPWR VGND sg13g2_decap_8
XFILLER_17_491 VPWR VGND sg13g2_decap_8
XdigitalH.g\[124\].u.inv VPWR digitalH.g\[124\].u.OUTN net21 VGND sg13g2_inv_1
XdigitalL.g\[29\].u.buff net83 digitalL.g\[29\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[15\].u.inv VPWR digitalL.g\[15\].u.OUTN net74 VGND sg13g2_inv_1
XFILLER_20_634 VPWR VGND sg13g2_decap_8
XFILLER_32_494 VPWR VGND sg13g2_decap_8
XFILLER_22_18 VPWR VGND sg13g2_decap_8
Xfanout113 net114 net113 VPWR VGND sg13g2_buf_1
Xfanout102 net106 net102 VPWR VGND sg13g2_buf_1
XFILLER_28_767 VPWR VGND sg13g2_decap_8
XFILLER_42_203 VPWR VGND sg13g2_decap_8
XFILLER_27_266 VPWR VGND sg13g2_decap_8
XFILLER_15_428 VPWR VGND sg13g2_decap_8
XFILLER_24_984 VPWR VGND sg13g2_decap_8
XFILLER_11_645 VPWR VGND sg13g2_decap_8
XFILLER_23_494 VPWR VGND sg13g2_decap_8
XFILLER_10_166 VPWR VGND sg13g2_decap_8
XFILLER_7_638 VPWR VGND sg13g2_decap_8
XFILLER_6_148 VPWR VGND sg13g2_decap_8
XFILLER_12_95 VPWR VGND sg13g2_decap_8
XFILLER_3_855 VPWR VGND sg13g2_decap_8
XFILLER_2_365 VPWR VGND sg13g2_decap_8
XFILLER_19_9 VPWR VGND sg13g2_decap_8
XFILLER_19_723 VPWR VGND sg13g2_decap_8
XFILLER_18_211 VPWR VGND sg13g2_decap_8
XFILLER_46_553 VPWR VGND sg13g2_decap_8
XFILLER_37_70 VPWR VGND sg13g2_decap_8
XFILLER_33_203 VPWR VGND sg13g2_decap_8
XFILLER_18_288 VPWR VGND sg13g2_decap_8
XFILLER_41_280 VPWR VGND sg13g2_decap_8
XFILLER_30_998 VPWR VGND sg13g2_decap_8
XFILLER_25_1005 VPWR VGND sg13g2_decap_8
XFILLER_17_29 VPWR VGND sg13g2_decap_8
XFILLER_37_553 VPWR VGND sg13g2_decap_8
XFILLER_25_704 VPWR VGND sg13g2_decap_8
XdigitalL.g\[111\].u.inv VPWR digitalL.g\[111\].u.OUTN net79 VGND sg13g2_inv_1
XFILLER_24_214 VPWR VGND sg13g2_decap_8
XFILLER_40_707 VPWR VGND sg13g2_decap_8
XFILLER_33_28 VPWR VGND sg13g2_decap_8
XFILLER_32_291 VPWR VGND sg13g2_decap_8
XFILLER_20_431 VPWR VGND sg13g2_decap_8
XdigitalH.g\[61\].u.inv VPWR digitalH.g\[61\].u.OUTN net53 VGND sg13g2_inv_1
XFILLER_21_976 VPWR VGND sg13g2_decap_8
XFILLER_0_847 VPWR VGND sg13g2_decap_8
XFILLER_16_715 VPWR VGND sg13g2_decap_4
XFILLER_28_564 VPWR VGND sg13g2_decap_8
XFILLER_15_225 VPWR VGND sg13g2_decap_8
XFILLER_43_567 VPWR VGND sg13g2_decap_8
XFILLER_31_718 VPWR VGND sg13g2_decap_8
XFILLER_30_228 VPWR VGND sg13g2_decap_8
XFILLER_24_781 VPWR VGND sg13g2_decap_8
XFILLER_11_442 VPWR VGND sg13g2_decap_8
XFILLER_23_291 VPWR VGND sg13g2_decap_8
XFILLER_7_435 VPWR VGND sg13g2_decap_8
XFILLER_3_652 VPWR VGND sg13g2_decap_8
XFILLER_2_162 VPWR VGND sg13g2_decap_8
XFILLER_48_91 VPWR VGND sg13g2_decap_8
XFILLER_47_840 VPWR VGND sg13g2_decap_8
XFILLER_19_520 VPWR VGND sg13g2_decap_8
XFILLER_0_21 VPWR VGND sg13g2_decap_8
XFILLER_46_350 VPWR VGND sg13g2_decap_8
XFILLER_19_597 VPWR VGND sg13g2_decap_8
XFILLER_0_98 VPWR VGND sg13g2_decap_8
XFILLER_34_567 VPWR VGND sg13g2_decap_8
XFILLER_22_718 VPWR VGND sg13g2_decap_8
XFILLER_21_228 VPWR VGND sg13g2_decap_8
XFILLER_9_85 VPWR VGND sg13g2_decap_8
XFILLER_31_1020 VPWR VGND sg13g2_decap_8
XFILLER_28_39 VPWR VGND sg13g2_decap_8
XdigitalL.g\[44\].u.buff net94 digitalL.g\[44\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_37_350 VPWR VGND sg13g2_decap_8
XFILLER_25_501 VPWR VGND sg13g2_decap_8
XFILLER_44_49 VPWR VGND sg13g2_decap_8
XFILLER_13_729 VPWR VGND sg13g2_decap_8
XFILLER_40_504 VPWR VGND sg13g2_decap_8
XFILLER_25_578 VPWR VGND sg13g2_decap_8
XFILLER_12_228 VPWR VGND sg13g2_decap_8
XFILLER_5_939 VPWR VGND sg13g2_decap_8
XFILLER_4_449 VPWR VGND sg13g2_decap_8
XFILLER_0_644 VPWR VGND sg13g2_decap_8
XFILLER_48_637 VPWR VGND sg13g2_decap_8
XFILLER_47_147 VPWR VGND sg13g2_decap_8
XFILLER_29_851 VPWR VGND sg13g2_decap_8
XFILLER_18_50 VPWR VGND sg13g2_decap_8
XFILLER_16_512 VPWR VGND sg13g2_decap_8
XFILLER_44_843 VPWR VGND sg13g2_decap_8
XFILLER_28_361 VPWR VGND sg13g2_decap_8
XFILLER_16_589 VPWR VGND sg13g2_decap_8
XFILLER_43_364 VPWR VGND sg13g2_decap_8
XFILLER_31_515 VPWR VGND sg13g2_decap_8
XFILLER_8_722 VPWR VGND sg13g2_decap_8
XFILLER_7_232 VPWR VGND sg13g2_decap_8
XFILLER_22_4 VPWR VGND sg13g2_decap_8
XFILLER_39_637 VPWR VGND sg13g2_decap_8
XFILLER_22_1019 VPWR VGND sg13g2_decap_8
XFILLER_38_147 VPWR VGND sg13g2_decap_8
XFILLER_19_394 VPWR VGND sg13g2_decap_8
XFILLER_34_364 VPWR VGND sg13g2_decap_8
XFILLER_22_515 VPWR VGND sg13g2_decap_8
XFILLER_30_592 VPWR VGND sg13g2_decap_8
XFILLER_30_18 VPWR VGND sg13g2_decap_8
XFILLER_39_49 VPWR VGND sg13g2_decap_8
XFILLER_17_309 VPWR VGND sg13g2_decap_8
XFILLER_29_158 VPWR VGND sg13g2_decap_8
XFILLER_26_865 VPWR VGND sg13g2_decap_8
XFILLER_13_526 VPWR VGND sg13g2_decap_8
XdigitalH.g\[35\].u.buff net44 digitalH.g\[35\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_40_301 VPWR VGND sg13g2_decap_8
XFILLER_25_375 VPWR VGND sg13g2_decap_8
XdigitalL.g\[63\].u.inv VPWR digitalL.g\[63\].u.OUTN net105 VGND sg13g2_inv_1
XFILLER_9_519 VPWR VGND sg13g2_decap_8
XFILLER_40_378 VPWR VGND sg13g2_decap_8
XFILLER_21_592 VPWR VGND sg13g2_decap_8
XFILLER_5_736 VPWR VGND sg13g2_decap_8
XFILLER_4_246 VPWR VGND sg13g2_decap_8
XFILLER_45_1008 VPWR VGND sg13g2_decap_8
XFILLER_20_95 VPWR VGND sg13g2_decap_8
XFILLER_1_931 VPWR VGND sg13g2_decap_8
XFILLER_0_441 VPWR VGND sg13g2_decap_8
XFILLER_49_924 VPWR VGND sg13g2_decap_8
XFILLER_48_434 VPWR VGND sg13g2_decap_8
XFILLER_29_60 VPWR VGND sg13g2_decap_8
XFILLER_44_651 VPWR VGND sg13g2_decap_8
XFILLER_45_70 VPWR VGND sg13g2_decap_8
XFILLER_43_161 VPWR VGND sg13g2_decap_8
XFILLER_32_824 VPWR VGND sg13g2_fill_1
XFILLER_32_802 VPWR VGND sg13g2_fill_2
XFILLER_16_386 VPWR VGND sg13g2_decap_8
XFILLER_31_312 VPWR VGND sg13g2_decap_8
XFILLER_32_879 VPWR VGND sg13g2_fill_1
XFILLER_31_389 VPWR VGND sg13g2_decap_8
XFILLER_12_592 VPWR VGND sg13g2_decap_8
XFILLER_8_596 VPWR VGND sg13g2_decap_8
XFILLER_6_64 VPWR VGND sg13g2_decap_8
XFILLER_39_434 VPWR VGND sg13g2_decap_8
XFILLER_35_651 VPWR VGND sg13g2_decap_8
XFILLER_25_18 VPWR VGND sg13g2_decap_8
XFILLER_19_191 VPWR VGND sg13g2_decap_8
XFILLER_34_161 VPWR VGND sg13g2_decap_8
XFILLER_23_802 VPWR VGND sg13g2_decap_8
XFILLER_22_312 VPWR VGND sg13g2_decap_8
XFILLER_23_879 VPWR VGND sg13g2_decap_8
XFILLER_41_28 VPWR VGND sg13g2_decap_8
XFILLER_31_890 VPWR VGND sg13g2_fill_2
XFILLER_22_389 VPWR VGND sg13g2_decap_8
XFILLER_9_8 VPWR VGND sg13g2_decap_8
XdigitalH.g\[119\].u.inv VPWR digitalH.g\[119\].u.OUTN net34 VGND sg13g2_inv_1
XFILLER_1_238 VPWR VGND sg13g2_decap_8
XFILLER_17_106 VPWR VGND sg13g2_decap_8
XFILLER_46_938 VPWR VGND sg13g2_decap_8
XFILLER_45_448 VPWR VGND sg13g2_decap_8
XFILLER_32_109 VPWR VGND sg13g2_decap_8
XFILLER_26_662 VPWR VGND sg13g2_decap_8
XFILLER_13_323 VPWR VGND sg13g2_decap_8
XFILLER_25_172 VPWR VGND sg13g2_decap_8
XFILLER_9_316 VPWR VGND sg13g2_decap_8
XFILLER_41_665 VPWR VGND sg13g2_decap_8
XFILLER_40_175 VPWR VGND sg13g2_decap_8
XFILLER_5_533 VPWR VGND sg13g2_decap_8
XdigitalL.g\[4\].u.inv VPWR digitalL.g\[4\].u.OUTN net71 VGND sg13g2_inv_1
XFILLER_49_721 VPWR VGND sg13g2_decap_8
XFILLER_48_231 VPWR VGND sg13g2_decap_8
XFILLER_49_798 VPWR VGND sg13g2_decap_8
XFILLER_36_448 VPWR VGND sg13g2_decap_8
XFILLER_17_673 VPWR VGND sg13g2_decap_8
XFILLER_23_109 VPWR VGND sg13g2_decap_8
XFILLER_16_183 VPWR VGND sg13g2_decap_8
XFILLER_32_676 VPWR VGND sg13g2_decap_8
XFILLER_20_805 VPWR VGND sg13g2_decap_8
XFILLER_31_186 VPWR VGND sg13g2_decap_8
XFILLER_8_393 VPWR VGND sg13g2_decap_8
XdigitalH.g\[120\].u.inv VPWR digitalH.g\[120\].u.OUTN net34 VGND sg13g2_inv_1
XdigitalL.g\[11\].u.inv VPWR digitalL.g\[11\].u.OUTN net73 VGND sg13g2_inv_1
XFILLER_39_231 VPWR VGND sg13g2_decap_8
XFILLER_36_28 VPWR VGND sg13g2_decap_8
XFILLER_28_949 VPWR VGND sg13g2_decap_8
XFILLER_27_448 VPWR VGND sg13g2_decap_8
XFILLER_23_676 VPWR VGND sg13g2_decap_8
XFILLER_10_348 VPWR VGND sg13g2_decap_8
XFILLER_22_186 VPWR VGND sg13g2_decap_8
XdigitalL.g\[106\].u.inv VPWR digitalL.g\[106\].u.OUTN net86 VGND sg13g2_inv_1
XFILLER_2_547 VPWR VGND sg13g2_decap_8
XdigitalH.g\[56\].u.inv VPWR digitalH.g\[56\].u.OUTN net52 VGND sg13g2_inv_1
XdigitalH.g\[50\].u.buff net54 digitalH.g\[50\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_735 VPWR VGND sg13g2_decap_8
XFILLER_45_245 VPWR VGND sg13g2_decap_8
XFILLER_14_610 VPWR VGND sg13g2_decap_8
XFILLER_13_120 VPWR VGND sg13g2_decap_8
XFILLER_14_687 VPWR VGND sg13g2_decap_8
XFILLER_9_113 VPWR VGND sg13g2_decap_8
XFILLER_41_462 VPWR VGND sg13g2_decap_8
XFILLER_13_197 VPWR VGND sg13g2_decap_8
XFILLER_5_330 VPWR VGND sg13g2_decap_8
XFILLER_6_864 VPWR VGND sg13g2_fill_1
XFILLER_6_886 VPWR VGND sg13g2_decap_4
XFILLER_3_43 VPWR VGND sg13g2_decap_8
XFILLER_3_1027 VPWR VGND sg13g2_fill_2
XFILLER_3_1016 VPWR VGND sg13g2_decap_8
XFILLER_49_595 VPWR VGND sg13g2_decap_8
XFILLER_37_735 VPWR VGND sg13g2_decap_4
XFILLER_36_245 VPWR VGND sg13g2_decap_8
XFILLER_17_470 VPWR VGND sg13g2_decap_8
XFILLER_32_473 VPWR VGND sg13g2_decap_8
XFILLER_20_613 VPWR VGND sg13g2_decap_8
XFILLER_9_680 VPWR VGND sg13g2_decap_8
XdigitalL.g\[69\].u.buff net109 digitalL.g\[69\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_8_190 VPWR VGND sg13g2_decap_8
Xfanout103 net106 net103 VPWR VGND sg13g2_buf_1
Xfanout114 net1 net114 VPWR VGND sg13g2_buf_1
XFILLER_47_49 VPWR VGND sg13g2_decap_8
XFILLER_28_746 VPWR VGND sg13g2_decap_8
XFILLER_15_407 VPWR VGND sg13g2_decap_8
XFILLER_27_245 VPWR VGND sg13g2_decap_8
XFILLER_43_749 VPWR VGND sg13g2_decap_8
XFILLER_42_259 VPWR VGND sg13g2_decap_8
XFILLER_24_963 VPWR VGND sg13g2_decap_8
XFILLER_11_624 VPWR VGND sg13g2_decap_8
XFILLER_23_473 VPWR VGND sg13g2_decap_8
XFILLER_10_145 VPWR VGND sg13g2_decap_8
XFILLER_7_617 VPWR VGND sg13g2_decap_8
XFILLER_6_127 VPWR VGND sg13g2_decap_8
XFILLER_12_74 VPWR VGND sg13g2_decap_8
XFILLER_3_834 VPWR VGND sg13g2_decap_8
XFILLER_2_344 VPWR VGND sg13g2_decap_8
XFILLER_19_702 VPWR VGND sg13g2_decap_8
XFILLER_46_532 VPWR VGND sg13g2_decap_8
XFILLER_18_267 VPWR VGND sg13g2_decap_8
XFILLER_33_259 VPWR VGND sg13g2_decap_8
XFILLER_18_1024 VPWR VGND sg13g2_decap_4
XFILLER_30_922 VPWR VGND sg13g2_decap_8
XFILLER_14_484 VPWR VGND sg13g2_decap_8
XFILLER_6_694 VPWR VGND sg13g2_decap_8
XFILLER_25_1028 VPWR VGND sg13g2_fill_1
XFILLER_49_392 VPWR VGND sg13g2_decap_8
XFILLER_37_532 VPWR VGND sg13g2_decap_8
XFILLER_18_790 VPWR VGND sg13g2_fill_1
XFILLER_32_270 VPWR VGND sg13g2_decap_8
XFILLER_21_955 VPWR VGND sg13g2_decap_8
XFILLER_20_410 VPWR VGND sg13g2_decap_8
XFILLER_20_487 VPWR VGND sg13g2_decap_8
XFILLER_0_826 VPWR VGND sg13g2_decap_8
XFILLER_48_819 VPWR VGND sg13g2_decap_8
XFILLER_47_329 VPWR VGND sg13g2_decap_8
XFILLER_28_543 VPWR VGND sg13g2_decap_8
XFILLER_15_204 VPWR VGND sg13g2_decap_8
XFILLER_43_546 VPWR VGND sg13g2_decap_8
XFILLER_30_207 VPWR VGND sg13g2_decap_8
XFILLER_24_760 VPWR VGND sg13g2_decap_8
XFILLER_11_421 VPWR VGND sg13g2_decap_8
XFILLER_23_270 VPWR VGND sg13g2_decap_8
XFILLER_7_414 VPWR VGND sg13g2_decap_8
XFILLER_11_498 VPWR VGND sg13g2_decap_8
XFILLER_23_95 VPWR VGND sg13g2_decap_8
XFILLER_3_631 VPWR VGND sg13g2_decap_8
XFILLER_2_141 VPWR VGND sg13g2_decap_8
XdigitalL.g\[58\].u.inv VPWR digitalL.g\[58\].u.OUTN net104 VGND sg13g2_inv_1
XFILLER_48_70 VPWR VGND sg13g2_decap_8
XFILLER_38_329 VPWR VGND sg13g2_decap_8
XFILLER_0_1008 VPWR VGND sg13g2_decap_8
XFILLER_0_77 VPWR VGND sg13g2_decap_8
XFILLER_47_896 VPWR VGND sg13g2_decap_8
XFILLER_19_576 VPWR VGND sg13g2_decap_8
XFILLER_34_546 VPWR VGND sg13g2_decap_8
XFILLER_21_207 VPWR VGND sg13g2_decap_8
XFILLER_14_281 VPWR VGND sg13g2_decap_8
XFILLER_9_64 VPWR VGND sg13g2_decap_8
XFILLER_30_774 VPWR VGND sg13g2_decap_8
XFILLER_6_491 VPWR VGND sg13g2_decap_8
XFILLER_43_0 VPWR VGND sg13g2_decap_8
XFILLER_28_18 VPWR VGND sg13g2_decap_8
XFILLER_13_708 VPWR VGND sg13g2_decap_8
XFILLER_44_28 VPWR VGND sg13g2_decap_8
XFILLER_25_557 VPWR VGND sg13g2_decap_8
XFILLER_12_207 VPWR VGND sg13g2_decap_8
XdigitalL.g\[84\].u.buff net99 digitalL.g\[84\].u.OUTP VPWR VGND sg13g2_buf_1
XdigitalL.g\[13\].u.buff net73 digitalL.g\[13\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_21_785 VPWR VGND sg13g2_decap_8
XFILLER_20_284 VPWR VGND sg13g2_decap_8
XFILLER_5_918 VPWR VGND sg13g2_decap_8
XdigitalH.g\[8\].u.buff net25 digitalH.g\[8\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_4_428 VPWR VGND sg13g2_decap_8
XdigitalH.g\[107\].u.buff net39 digitalH.g\[107\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_0_623 VPWR VGND sg13g2_decap_8
XFILLER_48_616 VPWR VGND sg13g2_decap_8
XFILLER_47_126 VPWR VGND sg13g2_decap_8
XFILLER_29_830 VPWR VGND sg13g2_decap_8
XFILLER_28_340 VPWR VGND sg13g2_decap_8
XFILLER_43_343 VPWR VGND sg13g2_decap_8
XFILLER_16_568 VPWR VGND sg13g2_decap_8
XFILLER_44_899 VPWR VGND sg13g2_decap_8
XFILLER_8_701 VPWR VGND sg13g2_decap_8
XFILLER_7_211 VPWR VGND sg13g2_decap_8
XFILLER_11_295 VPWR VGND sg13g2_decap_8
XFILLER_7_288 VPWR VGND sg13g2_decap_8
XFILLER_4_995 VPWR VGND sg13g2_decap_8
XFILLER_39_616 VPWR VGND sg13g2_decap_8
XFILLER_38_126 VPWR VGND sg13g2_decap_8
XFILLER_47_693 VPWR VGND sg13g2_decap_8
XFILLER_19_373 VPWR VGND sg13g2_decap_8
XFILLER_34_343 VPWR VGND sg13g2_decap_8
XFILLER_30_571 VPWR VGND sg13g2_decap_8
XFILLER_39_28 VPWR VGND sg13g2_decap_8
XFILLER_29_137 VPWR VGND sg13g2_decap_8
XFILLER_38_693 VPWR VGND sg13g2_decap_8
XFILLER_26_844 VPWR VGND sg13g2_decap_8
XFILLER_13_505 VPWR VGND sg13g2_decap_8
XFILLER_25_354 VPWR VGND sg13g2_decap_8
XdigitalH.g\[115\].u.inv VPWR digitalH.g\[115\].u.OUTN net36 VGND sg13g2_inv_1
XFILLER_40_357 VPWR VGND sg13g2_decap_8
XdigitalH.g\[75\].u.buff net60 digitalH.g\[75\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_21_571 VPWR VGND sg13g2_decap_8
XFILLER_5_715 VPWR VGND sg13g2_decap_8
XFILLER_4_225 VPWR VGND sg13g2_decap_8
XFILLER_20_74 VPWR VGND sg13g2_decap_8
XFILLER_1_910 VPWR VGND sg13g2_decap_8
XFILLER_0_420 VPWR VGND sg13g2_decap_8
XFILLER_49_903 VPWR VGND sg13g2_decap_8
XFILLER_1_987 VPWR VGND sg13g2_decap_8
XFILLER_0_497 VPWR VGND sg13g2_decap_8
XFILLER_48_413 VPWR VGND sg13g2_decap_8
XFILLER_44_630 VPWR VGND sg13g2_decap_8
XFILLER_16_365 VPWR VGND sg13g2_decap_8
XFILLER_43_140 VPWR VGND sg13g2_decap_8
XFILLER_32_858 VPWR VGND sg13g2_fill_1
XdigitalL.g\[0\].u.inv VPWR digitalL.g\[0\].u.OUTN net70 VGND sg13g2_inv_1
XFILLER_31_368 VPWR VGND sg13g2_decap_8
XFILLER_12_571 VPWR VGND sg13g2_decap_8
XFILLER_6_43 VPWR VGND sg13g2_decap_8
XFILLER_8_575 VPWR VGND sg13g2_decap_8
XFILLER_4_792 VPWR VGND sg13g2_decap_8
XFILLER_6_1014 VPWR VGND sg13g2_decap_8
XFILLER_39_413 VPWR VGND sg13g2_decap_8
XFILLER_48_980 VPWR VGND sg13g2_decap_8
XFILLER_47_490 VPWR VGND sg13g2_decap_8
XFILLER_35_630 VPWR VGND sg13g2_decap_8
XFILLER_19_170 VPWR VGND sg13g2_decap_8
XFILLER_34_140 VPWR VGND sg13g2_decap_8
XFILLER_23_858 VPWR VGND sg13g2_decap_8
XFILLER_22_368 VPWR VGND sg13g2_decap_8
XFILLER_2_729 VPWR VGND sg13g2_decap_8
XFILLER_1_217 VPWR VGND sg13g2_decap_8
XFILLER_46_917 VPWR VGND sg13g2_decap_8
XFILLER_45_427 VPWR VGND sg13g2_decap_8
XFILLER_38_490 VPWR VGND sg13g2_decap_8
XFILLER_26_641 VPWR VGND sg13g2_decap_8
XdigitalL.g\[102\].u.inv VPWR digitalL.g\[102\].u.OUTN net87 VGND sg13g2_inv_1
XFILLER_25_151 VPWR VGND sg13g2_decap_8
XFILLER_13_302 VPWR VGND sg13g2_decap_8
XFILLER_41_644 VPWR VGND sg13g2_decap_8
XFILLER_13_379 VPWR VGND sg13g2_decap_8
XFILLER_15_85 VPWR VGND sg13g2_decap_8
XFILLER_40_154 VPWR VGND sg13g2_decap_8
XdigitalH.g\[52\].u.inv VPWR digitalH.g\[52\].u.OUTN net50 VGND sg13g2_inv_1
XFILLER_5_512 VPWR VGND sg13g2_decap_8
XdigitalH.g\[122\].u.buff net33 digitalH.g\[122\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_31_95 VPWR VGND sg13g2_decap_8
XFILLER_5_589 VPWR VGND sg13g2_decap_8
Xoutput5 net5 uio_out[0] VPWR VGND sg13g2_buf_1
XFILLER_49_700 VPWR VGND sg13g2_decap_8
XFILLER_48_210 VPWR VGND sg13g2_decap_8
XFILLER_1_784 VPWR VGND sg13g2_decap_8
XFILLER_0_294 VPWR VGND sg13g2_decap_8
XFILLER_49_777 VPWR VGND sg13g2_decap_8
XFILLER_48_287 VPWR VGND sg13g2_decap_8
XFILLER_36_427 VPWR VGND sg13g2_decap_8
XFILLER_17_652 VPWR VGND sg13g2_decap_8
XFILLER_16_162 VPWR VGND sg13g2_decap_8
XFILLER_45_994 VPWR VGND sg13g2_decap_8
XFILLER_32_655 VPWR VGND sg13g2_decap_8
XFILLER_31_165 VPWR VGND sg13g2_decap_8
XFILLER_20_817 VPWR VGND sg13g2_decap_4
XFILLER_8_372 VPWR VGND sg13g2_decap_8
XFILLER_28_1026 VPWR VGND sg13g2_fill_2
XFILLER_39_210 VPWR VGND sg13g2_decap_8
XFILLER_28_928 VPWR VGND sg13g2_decap_8
XFILLER_39_287 VPWR VGND sg13g2_decap_8
XFILLER_27_427 VPWR VGND sg13g2_decap_8
XFILLER_23_655 VPWR VGND sg13g2_decap_8
XFILLER_22_165 VPWR VGND sg13g2_decap_8
XFILLER_10_327 VPWR VGND sg13g2_decap_8
XFILLER_6_309 VPWR VGND sg13g2_decap_8
XFILLER_2_526 VPWR VGND sg13g2_decap_8
XdigitalL.g\[112\].u.buff net79 digitalL.g\[112\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_46_714 VPWR VGND sg13g2_decap_8
XFILLER_45_224 VPWR VGND sg13g2_decap_8
XFILLER_18_449 VPWR VGND sg13g2_decap_8
XdigitalH.g\[90\].u.buff net56 digitalH.g\[90\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_27_994 VPWR VGND sg13g2_decap_8
XFILLER_14_666 VPWR VGND sg13g2_decap_8
XFILLER_41_441 VPWR VGND sg13g2_decap_8
XFILLER_26_95 VPWR VGND sg13g2_decap_8
XFILLER_13_176 VPWR VGND sg13g2_decap_8
XFILLER_6_810 VPWR VGND sg13g2_decap_4
XFILLER_9_169 VPWR VGND sg13g2_decap_8
XFILLER_6_876 VPWR VGND sg13g2_decap_4
XFILLER_5_386 VPWR VGND sg13g2_decap_8
XdigitalenL.g\[2\].u.buff net3 digitalenL.g\[2\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_7 VPWR VGND sg13g2_decap_8
XFILLER_3_22 VPWR VGND sg13g2_decap_8
XFILLER_1_581 VPWR VGND sg13g2_decap_8
XFILLER_49_574 VPWR VGND sg13g2_decap_8
XFILLER_3_99 VPWR VGND sg13g2_decap_8
XFILLER_37_714 VPWR VGND sg13g2_decap_8
XFILLER_36_224 VPWR VGND sg13g2_decap_8
XFILLER_18_961 VPWR VGND sg13g2_fill_1
XFILLER_45_791 VPWR VGND sg13g2_decap_8
XFILLER_32_452 VPWR VGND sg13g2_decap_8
XFILLER_20_669 VPWR VGND sg13g2_decap_8
Xfanout104 net106 net104 VPWR VGND sg13g2_buf_1
XdigitalL.g\[38\].u.buff net93 digitalL.g\[38\].u.OUTP VPWR VGND sg13g2_buf_1
Xfanout115 net1 net115 VPWR VGND sg13g2_buf_1
XdigitalL.g\[3\].u.buff net70 digitalL.g\[3\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_28 VPWR VGND sg13g2_decap_8
XFILLER_28_725 VPWR VGND sg13g2_decap_8
XFILLER_27_224 VPWR VGND sg13g2_decap_8
XFILLER_43_728 VPWR VGND sg13g2_decap_8
XFILLER_42_238 VPWR VGND sg13g2_decap_8
XFILLER_24_942 VPWR VGND sg13g2_decap_8
XFILLER_11_603 VPWR VGND sg13g2_decap_8
XFILLER_23_452 VPWR VGND sg13g2_decap_8
XFILLER_10_124 VPWR VGND sg13g2_decap_8
XFILLER_6_106 VPWR VGND sg13g2_decap_8
XFILLER_12_53 VPWR VGND sg13g2_decap_8
XFILLER_3_813 VPWR VGND sg13g2_decap_8
XFILLER_2_323 VPWR VGND sg13g2_decap_8
XFILLER_46_511 VPWR VGND sg13g2_decap_8
XFILLER_19_758 VPWR VGND sg13g2_fill_2
XFILLER_18_246 VPWR VGND sg13g2_decap_8
XFILLER_46_588 VPWR VGND sg13g2_decap_8
XFILLER_27_791 VPWR VGND sg13g2_decap_8
XFILLER_33_238 VPWR VGND sg13g2_decap_8
XFILLER_14_463 VPWR VGND sg13g2_decap_8
XdigitalL.g\[54\].u.inv VPWR digitalL.g\[54\].u.OUTN net103 VGND sg13g2_inv_1
XFILLER_42_794 VPWR VGND sg13g2_fill_2
XFILLER_10_691 VPWR VGND sg13g2_decap_8
XFILLER_6_673 VPWR VGND sg13g2_decap_8
XFILLER_5_183 VPWR VGND sg13g2_decap_8
XFILLER_2_890 VPWR VGND sg13g2_decap_8
XFILLER_49_371 VPWR VGND sg13g2_decap_8
XFILLER_37_511 VPWR VGND sg13g2_decap_8
XFILLER_37_588 VPWR VGND sg13g2_decap_8
XFILLER_25_739 VPWR VGND sg13g2_decap_8
XFILLER_24_249 VPWR VGND sg13g2_decap_8
XFILLER_21_934 VPWR VGND sg13g2_decap_8
XFILLER_20_466 VPWR VGND sg13g2_decap_8
XdigitalH.g\[99\].u.inv VPWR digitalH.g\[99\].u.OUTN net41 VGND sg13g2_inv_1
XFILLER_0_805 VPWR VGND sg13g2_decap_8
XdigitalH.g\[29\].u.buff net30 digitalH.g\[29\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_47_308 VPWR VGND sg13g2_decap_8
XFILLER_28_522 VPWR VGND sg13g2_decap_8
XFILLER_43_525 VPWR VGND sg13g2_decap_8
XFILLER_28_599 VPWR VGND sg13g2_decap_8
XFILLER_11_400 VPWR VGND sg13g2_decap_8
XFILLER_11_477 VPWR VGND sg13g2_decap_8
XFILLER_23_74 VPWR VGND sg13g2_decap_8
XFILLER_3_610 VPWR VGND sg13g2_decap_8
XFILLER_2_120 VPWR VGND sg13g2_decap_8
XFILLER_3_687 VPWR VGND sg13g2_decap_8
XFILLER_2_197 VPWR VGND sg13g2_decap_8
XFILLER_38_308 VPWR VGND sg13g2_decap_8
XFILLER_17_8 VPWR VGND sg13g2_decap_8
XFILLER_47_875 VPWR VGND sg13g2_decap_8
XFILLER_19_555 VPWR VGND sg13g2_decap_8
XFILLER_0_56 VPWR VGND sg13g2_decap_8
XFILLER_46_385 VPWR VGND sg13g2_decap_8
XFILLER_34_525 VPWR VGND sg13g2_decap_8
XFILLER_14_260 VPWR VGND sg13g2_decap_8
XFILLER_9_43 VPWR VGND sg13g2_decap_8
XFILLER_30_753 VPWR VGND sg13g2_decap_8
XFILLER_6_470 VPWR VGND sg13g2_decap_8
XFILLER_36_0 VPWR VGND sg13g2_decap_8
XFILLER_29_319 VPWR VGND sg13g2_decap_8
XFILLER_37_385 VPWR VGND sg13g2_decap_8
XFILLER_25_536 VPWR VGND sg13g2_decap_8
XFILLER_40_539 VPWR VGND sg13g2_decap_8
XFILLER_21_753 VPWR VGND sg13g2_decap_8
XFILLER_20_263 VPWR VGND sg13g2_decap_8
XFILLER_4_407 VPWR VGND sg13g2_decap_8
XdigitalL.g\[53\].u.buff net103 digitalL.g\[53\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_0_602 VPWR VGND sg13g2_decap_8
XdigitalH.g\[111\].u.inv VPWR digitalH.g\[111\].u.OUTN net37 VGND sg13g2_inv_1
XFILLER_0_679 VPWR VGND sg13g2_decap_8
XFILLER_47_105 VPWR VGND sg13g2_decap_8
XFILLER_44_812 VPWR VGND sg13g2_decap_4
XFILLER_29_886 VPWR VGND sg13g2_decap_8
XFILLER_18_85 VPWR VGND sg13g2_decap_8
XFILLER_16_547 VPWR VGND sg13g2_decap_8
XFILLER_43_322 VPWR VGND sg13g2_decap_8
XFILLER_28_396 VPWR VGND sg13g2_decap_8
XFILLER_44_878 VPWR VGND sg13g2_decap_8
XFILLER_43_399 VPWR VGND sg13g2_decap_8
XFILLER_34_84 VPWR VGND sg13g2_decap_8
XFILLER_11_274 VPWR VGND sg13g2_decap_8
XFILLER_7_267 VPWR VGND sg13g2_decap_8
XFILLER_4_974 VPWR VGND sg13g2_decap_8
XFILLER_3_484 VPWR VGND sg13g2_decap_8
XdigitalH.g\[47\].u.inv VPWR digitalH.g\[47\].u.OUTN net48 VGND sg13g2_inv_1
XFILLER_38_105 VPWR VGND sg13g2_decap_8
XFILLER_47_672 VPWR VGND sg13g2_decap_8
XFILLER_19_352 VPWR VGND sg13g2_decap_8
XFILLER_46_182 VPWR VGND sg13g2_decap_8
XFILLER_34_322 VPWR VGND sg13g2_decap_8
XFILLER_34_399 VPWR VGND sg13g2_decap_8
XFILLER_30_550 VPWR VGND sg13g2_decap_8
XFILLER_29_116 VPWR VGND sg13g2_decap_8
XFILLER_45_609 VPWR VGND sg13g2_decap_8
XFILLER_44_119 VPWR VGND sg13g2_decap_8
XFILLER_38_672 VPWR VGND sg13g2_decap_8
XFILLER_26_823 VPWR VGND sg13g2_decap_8
XFILLER_37_182 VPWR VGND sg13g2_decap_8
XFILLER_25_333 VPWR VGND sg13g2_decap_8
XFILLER_40_336 VPWR VGND sg13g2_decap_8
XFILLER_21_550 VPWR VGND sg13g2_decap_8
XFILLER_4_204 VPWR VGND sg13g2_decap_8
XdigitalH.g\[44\].u.buff net47 digitalH.g\[44\].u.OUTP VPWR VGND sg13g2_buf_1
XFILLER_20_53 VPWR VGND sg13g2_decap_8
XFILLER_1_966 VPWR VGND sg13g2_decap_8
XFILLER_0_476 VPWR VGND sg13g2_decap_8
XFILLER_49_959 VPWR VGND sg13g2_decap_8
XFILLER_48_469 VPWR VGND sg13g2_decap_8
XFILLER_36_609 VPWR VGND sg13g2_decap_8
XFILLER_29_95 VPWR VGND sg13g2_decap_8
XFILLER_35_119 VPWR VGND sg13g2_decap_8
XFILLER_29_683 VPWR VGND sg13g2_decap_8
XFILLER_28_193 VPWR VGND sg13g2_decap_8
XFILLER_16_344 VPWR VGND sg13g2_decap_8
XFILLER_44_686 VPWR VGND sg13g2_decap_8
XFILLER_43_196 VPWR VGND sg13g2_decap_8
XFILLER_31_347 VPWR VGND sg13g2_decap_8
XFILLER_12_550 VPWR VGND sg13g2_decap_8
XFILLER_8_554 VPWR VGND sg13g2_decap_8
XFILLER_6_22 VPWR VGND sg13g2_decap_8
XFILLER_4_771 VPWR VGND sg13g2_decap_8
XFILLER_6_99 VPWR VGND sg13g2_decap_8
XFILLER_3_281 VPWR VGND sg13g2_decap_8
XFILLER_39_469 VPWR VGND sg13g2_decap_8
XFILLER_27_609 VPWR VGND sg13g2_decap_8
XFILLER_35_686 VPWR VGND sg13g2_decap_8
XFILLER_23_837 VPWR VGND sg13g2_decap_8
XFILLER_34_196 VPWR VGND sg13g2_decap_8
XFILLER_22_347 VPWR VGND sg13g2_decap_8
XFILLER_10_509 VPWR VGND sg13g2_decap_8
XFILLER_31_881 VPWR VGND sg13g2_fill_1
XFILLER_2_708 VPWR VGND sg13g2_decap_8
XFILLER_45_406 VPWR VGND sg13g2_decap_8
XFILLER_26_620 VPWR VGND sg13g2_decap_8
XFILLER_25_130 VPWR VGND sg13g2_decap_8
XFILLER_41_623 VPWR VGND sg13g2_decap_8
XFILLER_26_697 VPWR VGND sg13g2_decap_8
XFILLER_13_358 VPWR VGND sg13g2_decap_8
XFILLER_15_64 VPWR VGND sg13g2_decap_8
XFILLER_40_133 VPWR VGND sg13g2_decap_8
XFILLER_31_74 VPWR VGND sg13g2_decap_8
XFILLER_5_568 VPWR VGND sg13g2_decap_8
Xoutput6 net6 uio_out[1] VPWR VGND sg13g2_buf_1
XFILLER_1_763 VPWR VGND sg13g2_decap_8
XFILLER_0_273 VPWR VGND sg13g2_decap_8
XFILLER_49_756 VPWR VGND sg13g2_decap_8
XFILLER_48_266 VPWR VGND sg13g2_decap_8
XFILLER_36_406 VPWR VGND sg13g2_decap_8
XFILLER_17_631 VPWR VGND sg13g2_decap_8
XFILLER_29_480 VPWR VGND sg13g2_decap_8
XFILLER_16_141 VPWR VGND sg13g2_decap_8
XFILLER_45_973 VPWR VGND sg13g2_decap_8
XFILLER_44_483 VPWR VGND sg13g2_decap_8
XFILLER_32_634 VPWR VGND sg13g2_decap_8
XFILLER_31_144 VPWR VGND sg13g2_decap_8
XFILLER_8_351 VPWR VGND sg13g2_decap_8
XFILLER_28_1005 VPWR VGND sg13g2_decap_8
XdigitalL.g\[49\].u.inv VPWR digitalL.g\[49\].u.OUTN net102 VGND sg13g2_inv_1
.ends
